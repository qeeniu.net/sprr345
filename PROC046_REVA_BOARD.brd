# Allegro board PROC046_REVA_BOARD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_QSPI_CSN0: length 63
  TOP w0.127: v1(176.41,106.87) 176.81,107.27 U1.J25 ; U72.7 v2(192.11,72.66)
  L08_SIG2 w0.102: 178.71,104.03 178.55,104.19 178.55,104.34 176.41,106.49 v1(176.41,106.87)
  L08_SIG2 w0.127: v2(186.05,76.47) 185.62,76.47 185.17,76.01 185.17,74.82 184.4,74.06 183.26,74.06 182.99,74.32 182.99,74.94 183.12,75.07 184.28,75.07 184.4,75.2 184.4,75.45 184.28,75.58 183.12,75.58 182.99,75.7 182.99,75.96 183.12,76.09 184.28,76.09 184.4,76.21 184.4,76.47 184.28,76.59 183.12,76.59 182.99,76.72 182.99,76.97 183.12,77.1 184.28,77.1 184.4,77.23 184.4,77.48 184.28,77.61 183.12,77.61 182.99,77.74 182.99,88.78 183.64,89.42 183.64,94.54 180.21,97.97 180.21,102.87 180.19,102.9 180.19,102.93 179.59,103.54 179.21,103.54 178.71,104.03
  BOTTOM w0.127: v2(186.05,76.47) 186.69,75.83 186.69,74.08 188.11,72.66 v2(192.11,72.66) 193.56,72.66 R745.2
SOC_QSPI_D0: length 58.6
  TOP w0.127: U1.J23 v1(176.41,110.61) ; U72.15 201.29,79.01 198.65,81.65 192.35,81.65 191.77,81.07 191.26,81.07 v2(190.93,80.74)
  L08_SIG2 w0.102: 183.39,104.03 183.39,105.15 183.42,105.24 183.43,105.26 183.87,105.7 183.87,106.53 183.58,106.82 181.46,106.82 179.99,108.29 179.99,108.3 179.77,108.53 179.75,108.53 179.15,109.13 177.86,109.13 176.62,110.37 176.62,110.4 v1(176.41,110.61)
  L08_SIG2 w0.127: v2(190.93,80.74) 191.26,81.07 191.26,83.2 189.74,84.72 189.74,91.58 188.29,93.03 188.29,94.58 189.15,95.44 189.15,96.01 189.28,96.14 189.97,96.14 190.1,96.27 190.1,96.52 189.97,96.65 189.28,96.65 189.15,96.77 189.15,97.03 189.28,97.16 189.97,97.16 190.1,97.28 190.1,97.54 189.97,97.66 189.28,97.66 189.15,97.79 189.15,98.23 189.54,98.62 189.54,99.17 188.08,100.62 185.32,100.62 184.55,101.39 184.25,101.39 183.39,102.25 183.39,104.03
SOC_QSPI_D1: length 58.8
  TOP w0.127: U72.8 v2(192.11,71.39) ; U1.J22 v1(176.41,111.41)
  L08_SIG2 w0.102: v1(176.41,111.41) 176.83,111 176.83,110.46 177.93,109.35 179.31,109.35 180.9,107.76 182.68,107.76 182.97,107.47 183.22,107.47 184.07,106.61 184.07,105.45 183.72,105.09 183.72,104.26 183.64,104.19 183.64,104.03
  L08_SIG2 w0.127: v2(192.11,71.39) 191.9,71.39 191.77,71.52 191.77,71.77 191.9,71.9 192.41,71.9 192.57,72.06 192.57,73.22 192.44,73.35 191.89,73.35 191.76,73.47 191.76,73.73 191.89,73.85 192.44,73.85 192.57,73.98 192.57,74.24 192.44,74.36 191.89,74.36 191.76,74.49 191.76,74.74 191.89,74.87 192.44,74.87 192.57,75 192.57,75.25 192.44,75.38 191.89,75.38 191.82,75.44 191.82,75.82 191.89,75.89 192.44,75.89 192.57,76.01 192.57,76.64 191.13,78.07 191.13,80.28 191.52,80.66 191.52,83.39 190.12,84.79 190.12,91.79 189.36,92.55 189.36,93.72 189.48,93.84 189.48,93.9 190.34,94.75 190.34,97.89 189.79,98.44 189.79,99.39 188.31,100.87 185.47,100.87 184.2,102.13 184.19,102.13 183.64,102.68 183.64,104.03
SOC_QSPI_D2: length 63
  TOP w0.127: U1.J21 v1(177.21,113.01) ; U72.9 v2(204.43,71.39)
  L03_SIG1 w0.127: v2(192.25,78.31) 192.43,78.12 196.22,78.12 202.95,71.39 v2(204.43,71.39)
  L08_SIG2 w0.102: v1(177.21,113.01) 177.62,112.6 177.62,110.48 177.63,110.47 177.63,110.46 178.09,110 179.93,110 181.01,108.91 181.02,108.91 181.03,108.9 182.91,108.9 183.76,108.06 183.76,107.92 184.81,106.86 184.81,104.03
  L08_SIG2 w0.127: v2(192.25,78.31) 192.79,78.85 192.79,80.53 192.41,80.91 192.41,83.58 191.97,84.01 191.97,90.67 191.1,91.54 191.1,99.36 188.16,102.3 186.36,102.3 184.81,103.85 184.81,104.03
  BOTTOM w0.127: v2(204.43,71.39) 203.22,71.39 R746.2
SOC_QSPI_D3: length 60.4
  TOP w0.127: U1.J24 177.21,109.81 177.21,106.4 v1(176.41,105.6) ; v2(191.9,80.23) 191.95,80.28 U72.1
  L08_SIG2 w0.102: 177.67,104.03 177.48,104.22 177.48,104.54 v1(176.41,105.6)
  L08_SIG2 w0.127: v2(186.05,75.71) 186.05,75.33 184.4,73.67 183.01,73.67 182.75,73.93 182.75,88.91 183.39,89.55 183.39,90.14 183.26,90.27 182.88,90.27 182.75,90.39 182.75,90.65 182.88,90.78 183.26,90.78 183.39,90.9 183.39,91.16 183.26,91.28 182.88,91.28 182.75,91.41 182.75,91.66 182.88,91.79 183.26,91.79 183.39,91.92 183.39,94.38 179.18,98.58 179.18,102.82 178.92,103.09 178.61,103.09 177.67,104.03
  BOTTOM w0.127: R743.2 193.66,80.28 191.95,80.28 v2(191.9,80.23) 191.85,80.28 187.2,80.28 185.36,78.44 185.36,76.41 v2(186.05,75.71)
SOC_QSPI_RTCLK: length 55.3
  TOP w0.127: R740.2 190.32,82.69 v2(185.93,78.3) ; U1.K24 176.41,109.81 v1(176.41,108.14)
  L08_SIG2 w0.102: v1(176.41,108.14) 176.41,107.53 176.83,107.1 176.83,106.57 179.37,104.03
  L08_SIG2 w0.127: v2(185.93,78.3) 183.56,78.3 183.38,78.48 183.38,82.33 183.44,82.4 184.15,82.4 184.28,82.52 184.28,82.78 184.15,82.9 183.44,82.9 183.38,82.97 183.38,83.35 183.44,83.41 184.15,83.41 184.28,83.54 184.28,83.79 184.15,83.92 183.44,83.92 183.38,83.99 183.38,87.99 184.05,88.66 184.05,94.66 184.02,94.68 184.02,94.7 180.62,98.1 180.62,103.04 179.74,103.92 179.49,103.92 179.37,104.03
SOC_RESETFULLZ: length 20.8
  TOP w0.127: U24.18 90.17,185.43 91.57,186.83 100.2,186.83 101.98,188.61 101.98,191.28 103.01,192.31 R883.1 103.76,193.18 103.87,193.29 U138.3
SOC_RESETFULLZ_AND: length 120
  TOP w0.127: v2(109.09,190.39) 109.09,190.41 109.08,190.41 108.84,190.65 108.84,190.9 108.57,191.16 R881.1 108.08,192.17 107.75,192.49 107.2,192.49 107.02,192.67 U138.4 ; U1.W2 168.41,128.21 168.41,130.23 167.64,131 v1(167.64,131.1)
  L08_SIG2 w0.102: v1(167.64,131.1) 167.56,131.18 166.62,131.18 165.61,132.2 165.61,133.03 165.3,133.34 165.3,134.18 165.89,134.76 165.89,134.89
  L08_SIG2 w0.127: 165.89,134.89 165.89,135.6 161.61,139.88 161.61,145.16 161.25,145.52 161.25,148.03 161.8,148.58 161.8,149.7 161.4,150.09 161.4,152.69 161.89,153.18 161.89,155.31 161.38,155.82 161.38,170.04 161.14,170.28 161.14,183.14 153.76,190.51 153.71,190.51 153.7,190.53 109.21,190.53 109.09,190.41 v2(109.09,190.39)
SOC_RESETSTATZ: length 1061.2
  TOP w0.127: v2(79.4,47.92) 79.19,48.13 U58.2 ; U71.2 v1(189.86,73.82) ; v2(178.23,45.99) 178.74,45.48 U89.2 213.28,45.48 220.57,38.19 229.21,38.19 234.21,33.19 240.13,33.19 243.97,29.35 250.01,29.35 252.81,32.15 v2(262.76,32.15) ; v2(289.31,41.67) 289.31,39.38 288.8,38.88 287.53,38.88 287.27,38.62 287.27,37.7 U97.2 ; v2(130.02,24.35) 130.02,24.97 130.12,25.07 U106.2 ; U127.2 v2(209.02,185.03) ; U20.C12 v1(75.47,199.73) ; U1.Y2 167.61,128.21 v1(167.61,129.88) ; R378.2 v2(165.23,142.85) ; U36.2 v2(187.77,198.71) ; U91.2 v2(114.25,54.6) ; R42.2 v2(56.79,127.89) ; U5.2 v2(221.61,243.37)
  L03_SIG1 w0.102: 280.7,43.45 272.8,43.45 271.65,44.59 269.88,44.59 ; v1(75.47,199.73) 74.93,200.27 74.93,202.26 74.64,202.55 ; v1(167.61,129.88) 168.02,130.3 168.02,131.33 167.67,131.69 165.89,131.69 165.51,132.07 165.51,134.81 165.58,134.89
  L03_SIG1 w0.127: 165.58,134.89 165.58,135.47 164.52,136.54 164.52,142.14 v2(165.23,142.85) ; 269.88,44.59 266.83,44.59 262.76,40.53 v2(262.76,32.15) ; 74.64,202.55 72.53,204.66 70.69,204.66 69.7,205.65 61.52,205.65 58.37,202.5 57.3,202.5 54.89,204.92 v2(54.89,205.12) ; JP1.11 298.91,130.98 293.66,136.24 274.82,136.24 270.45,131.87 256.03,131.87 251.53,136.36 239.41,136.36 235.86,139.92 207.85,139.92 206.88,138.95 199.67,138.95 198.69,139.93 192.66,139.93 191.99,139.26 v2(188.62,139.26) ; v2(221.61,243.37) 220.45,242.2 220.45,234.69 217.04,231.28 217.04,216.93 222.76,211.22 222.76,193.56 217.45,188.25 212.24,188.25 v2(209.02,185.03) ; v2(79.4,47.92) 79.19,47.71 79.19,47.31 80.26,46.24 80.26,40.93 78.77,39.44 78.77,28.11 83.11,23.76 101.73,23.76 105.22,20.27 107.96,20.27 107.97,20.26 108.41,20.26 108.65,20.02 117.67,20.02 123.09,25.44 128.93,25.44 v2(130.02,24.35) 130.02,26.23 128.63,27.62 128.63,30.44 133.52,35.33 165.21,35.33 168.17,38.29 174.14,38.29 178.23,42.38 v2(178.23,45.99) 178.99,46.75 178.99,54.22 186.13,61.36 192.46,61.36 194.18,63.08 194.18,72.28 192.02,74.44 190.48,74.44 v1(189.86,73.82) ; v2(166.5,192.29) 166.5,192.74 166.51,192.75 166.51,193.58 169.66,196.73 171.3,196.73 172.21,197.64 172.21,199.52 174.28,201.59 177.73,201.59 177.83,201.69 184.79,201.69 v2(187.77,198.71) ; 280.7,43.45 282.27,43.45 285.06,40.65 288.29,40.65 v2(289.31,41.67)
  L08_SIG2 w0.127: JP1.11 297.89,128.9 297.89,72.02 295.15,69.28 295.15,47.79 289.31,41.95 v2(289.31,41.67) ; v2(165.23,142.85) 167.21,144.83 167.21,146.41 166.46,147.16 166.46,147.69 166.73,147.96 166.74,147.96 168.54,149.76 168.54,152.63 168,153.18 168,160.21 168.58,160.8 168.58,172.28 165.28,175.58 165.28,177.99 167.11,179.82 167.11,191.24 166.5,191.85 v2(166.5,192.29) ; v2(56.79,127.89) 56.79,106.97 33.08,83.26 33.08,52.66 36.83,48.91 78.41,48.91 v2(79.4,47.92)
  BOTTOM w0.127: v1(167.61,129.88) 168.19,130.47 169.2,130.47 170.21,131.47 170.21,132.6 170.87,133.26 172.11,133.26 175.21,136.36 182.89,136.36 184.66,138.14 184.98,138.14 185.18,138.34 186.75,138.34 187.66,139.26 v2(188.62,139.26) ; v2(79.4,47.92) 79.49,48.01 93.21,48.01 95.28,50.08 100.66,50.08 103.23,47.51 108.76,47.51 111.23,49.98 112.14,49.98 113.26,51.09 113.26,53.61 v2(114.25,54.6) ; v2(54.89,205.12) 55.37,204.64 55.37,182.96 57,181.33 57,171.95 52.58,167.53 52.58,126.38 53.59,125.36 55.88,125.36 56.79,126.28 v2(56.79,127.89) ; v2(187.77,198.71) 188.09,199.02 194.16,199.02 208.15,185.03 v2(209.02,185.03)
SOC_RESETZ: length 14.2
  TOP w0.127: U24.17 90.67,185.43 91.81,186.58 98.04,186.58 99.33,185.29 R238.1 99.98,183.53 100.22,183.77 U23.3
SOC_RESETZ_AND: length 129
  TOP w0.127: R239.1 v2(104.39,183.4) 104.03,183.77 U23.4 ; U1.W3 v1(169.21,127.41)
  L08_SIG2 w0.102: v1(169.21,127.41) 169.21,128.95 168.61,129.55 168.61,131.18 167.82,131.97 167.12,131.97 165.61,133.48 165.61,134.08 166.19,134.66 166.19,134.89
  L08_SIG2 w0.127: v2(104.39,183.4) 104.39,187.47 107.77,190.85 153.83,190.85 161.65,183.03 161.65,155.89 162.13,155.41 162.13,153.08 161.74,152.69 161.74,150.09 162.04,149.8 162.04,148.47 161.52,147.94 161.52,145.73 162.03,145.23 162.03,144.03 162.74,143.32 162.74,139.15 166.19,135.7 166.19,134.89
SOC_RGMII_RXCLK: length 91.4
  TOP w0.127: R560.1 v2(168.71,60.43) ; U1.A22 184.81,111.81 185.74,110.89 186.92,110.89 v1(188.29,109.51)
  L08_SIG2 w0.102: 189.1,108.62 189.1,108.7 v1(188.29,109.51)
  L08_SIG2 w0.127: 189.1,108.62 189.33,108.39 189.7,108.39 190.43,107.66 191.49,107.66 193.27,105.88 193.27,102.71 193.88,102.1 193.88,98.67 194.46,98.08 194.46,97.22 193.88,96.64 193.88,93.72 194.54,93.06 195.17,93.06 195.45,92.78 195.45,64.66 193.65,62.85 191.64,62.85 191.44,62.65 190.61,62.65 190.49,62.52 190.49,61.99 190.36,61.86 190.11,61.86 189.98,61.99 189.98,62.52 189.85,62.65 189.6,62.65 189.47,62.52 189.47,61.99 189.34,61.86 189.09,61.86 188.96,61.99 188.96,62.52 188.84,62.65 180.95,62.65 180.82,62.52 180.82,61.99 180.7,61.86 180.44,61.86 180.31,61.99 180.31,62.52 180.19,62.65 179.93,62.65 179.81,62.52 179.81,61.99 179.68,61.86 179.43,61.86 179.3,61.99 179.3,62.52 179.17,62.65 178.92,62.65 177.62,61.36 177.62,61 v2(177.09,60.47)
  BOTTOM w0.127: v2(168.71,60.43) 169.31,59.83 171.98,59.83 172.72,60.57 172.72,60.66 173.03,60.97 173.53,60.97 173.57,60.93 176.63,60.93 v2(177.09,60.47)
SOC_RGMII_RXCLK_R: length 10.6
  TOP w0.127: U92.35 170.47,55.63 168.71,57.39 R560.2 168.16,58.04 167.82,58.38 167.82,61.06 v2(168.71,61.95) R559.1
  BOTTOM w0.127: R559.1 v2(168.71,61.95)
SOC_RGMII_RXCTL: length 91.5
  TOP w0.127: U1.A24 185.05,110.21 v1(185.75,109.51) ; R554.1 v2(170.23,60.43)
  L08_SIG2 w0.102: 189.1,108.01 189.06,108.01 188.62,108.45 186.51,108.45 185.75,109.21 v1(185.75,109.51)
  L08_SIG2 w0.127: 189.1,108.01 189.54,108.01 190.27,107.28 191.21,107.28 192.86,105.63 192.86,102.45 193.37,101.95 193.37,97.27 193.5,97.14 193.5,92.98 194.27,92.21 194.27,92.03 193.84,91.6 193.84,91.42 194.02,91.24 194.2,91.24 194.63,91.67 194.81,91.67 195.02,91.45 195.02,90.92 194.89,90.79 194.06,90.79 193.93,90.66 193.93,90.41 194.06,90.28 194.89,90.28 195.02,90.15 195.02,66.89 194.54,66.42 194.36,66.42 194.03,66.75 193.85,66.75 193.67,66.57 193.67,66.39 194,66.06 194,65.88 193.94,65.81 193.94,65.63 194.78,64.79 194.78,64.62 194.6,64.44 194.42,64.44 193.58,65.27 193.4,65.27 193.22,65.09 193.22,64.91 194.06,64.08 194.06,63.9 193.88,63.72 193.7,63.72 192.86,64.55 192.68,64.55 192.5,64.37 192.5,64.19 193.08,63.61 193.08,63.43 192.9,63.25 192.73,63.25 192.14,63.84 191.96,63.84 191.21,63.08 178.51,63.08 176.94,61.51 v2(176.94,61.36)
  BOTTOM w0.127: v2(170.23,60.43) 171.16,61.36 v2(176.94,61.36)
SOC_RGMII_RXCTL_R: length 10.3
  TOP w0.127: R552.1 v2(170.23,61.95) 169.47,61.19 169.47,58.25 169.68,58.04 R554.2 170.23,57.94 171.49,56.68 171.49,55.81 171.47,55.79 U92.33
  BOTTOM w0.127: R552.1 v2(170.23,61.95)
SOC_RGMII_RXD0: length 92.1
  TOP w0.127: U1.B24 182.41,109.97 182.81,109.57 v1(182.81,108.14) ; R549.1 v2(171.75,60.43)
  L08_SIG2 w0.102: 184.02,104.03 184.02,104.97 184.33,105.27 184.33,106.72 183.18,107.86 183.09,107.86 v1(182.81,108.14)
  L08_SIG2 w0.127: v2(171.75,60.43) 172.34,60.43 172.47,60.56 172.47,60.87 172.59,61 172.79,61 172.91,61.13 172.91,61.38 172.79,61.51 172.59,61.51 172.47,61.63 172.47,62.43 172.34,62.55 171.83,62.55 171.7,62.68 171.7,62.94 171.83,63.06 172.34,63.06 172.47,63.19 172.47,63.77 172.72,64.02 176.91,64.02 177.77,64.89 186.54,64.89 186.79,65.14 186.79,65.32 186.12,65.99 186.12,66.17 186.3,66.35 186.47,66.35 187.15,65.68 187.33,65.68 187.51,65.86 187.51,66.04 186.83,66.71 186.83,66.89 187.01,67.07 187.19,67.07 187.87,66.4 188.05,66.4 188.23,66.58 188.23,66.75 187.55,67.43 187.55,67.61 187.73,67.79 187.91,67.79 188.59,67.11 188.76,67.11 188.94,67.29 188.94,67.47 188.27,68.15 188.27,68.33 188.45,68.51 188.63,68.51 189.3,67.83 189.48,67.83 189.66,68.01 189.66,68.19 188.99,68.87 188.99,69.04 189.17,69.22 189.35,69.22 190.02,68.55 190.2,68.55 190.38,68.73 190.38,68.91 189.71,69.58 189.71,69.76 189.89,69.94 190.07,69.94 190.74,69.27 190.92,69.27 191.1,69.45 191.1,69.63 190.43,70.3 190.43,70.48 190.61,70.66 190.79,70.66 191.46,69.99 191.64,69.99 192.96,71.31 192.96,76.8 191.52,78.25 191.52,79.31 191.97,79.77 192.15,79.77 192.41,80.02 192.41,80.37 191.9,80.87 191.9,83.55 191.52,83.93 191.52,90.54 190.53,91.53 190.53,92.01 189.86,92.67 189.86,93.74 190.72,94.6 190.72,98.99 188.47,101.25 185.63,101.25 184.36,102.51 184.34,102.51 184.02,102.83 184.02,104.03
SOC_RGMII_RXD0_R: length 9.9
  TOP w0.127: U92.32 171.97,57.18 171.75,57.39 R549.2 171.21,58.04 170.99,58.25 170.99,61.19 v2(171.75,61.95) R548.1
  BOTTOM w0.127: R548.1 v2(171.75,61.95)
SOC_RGMII_RXD1: length 91.7
  TOP w0.127: U1.C23 v1(182.01,111.41) ; R546.1 v2(173.28,60.43)
  L08_SIG2 w0.102: v1(182.01,111.41) 181.74,111.41 181.59,111.57 181.59,111.57 181.37,111.8 181.05,111.8 180.83,111.57 180.83,111.26 181.39,110.7 182.46,110.7 182.65,110.89 185.55,110.89 186.64,109.8 187.3,109.8 187.88,110.38 188.82,110.38 189.02,110.17 189.1,110.17
  L08_SIG2 w0.127: v2(180.8,59.65) 194.01,59.65 197.94,63.59 197.94,96.64 196.77,97.8 196.77,100.51 196.57,100.71 196.57,106.19 195.17,107.58 193.67,107.58 191.08,110.17 189.1,110.17
  BOTTOM w0.127: v2(180.8,59.65) 180.62,59.83 173.88,59.83 v2(173.28,60.43)
SOC_RGMII_RXD1_R: length 10.2
  TOP w0.127: U92.31 172.47,55.79 172.45,55.81 172.45,56.56 173.28,57.39 R546.2 172.73,58.04 172.52,58.25 172.52,61.19 v2(173.28,61.95) R541.1
  BOTTOM w0.127: R541.1 v2(173.28,61.95)
SOC_RGMII_RXD2: length 91.4
  TOP w0.127: R538.1 v2(174.8,60.43) ; v1(184.45,109.46) 184.1,109.82 183.02,109.82 182.8,110.03 182.8,110.62 U1.B23
  L08_SIG2 w0.102: v1(184.45,109.46) 186.18,107.74 188.59,107.74 189.1,107.23
  L08_SIG2 w0.127: 189.1,107.23 191.54,104.79 191.54,101.41 192.15,100.8 192.15,98.21 191.87,97.93 191.87,91.73 192.74,90.87 192.74,89.4 193.88,88.25 193.88,77.48 193.73,77.33 193.73,68.54 192.26,67.08 192.08,67.08 191.6,67.56 191.6,67.74 191.89,68.04 191.89,68.22 191.71,68.4 191.54,68.4 191.24,68.1 191.06,68.1 190.81,68.35 190.63,68.35 190.45,68.17 190.45,67.99 190.52,67.92 190.52,67.74 189.5,66.72 189.5,66.55 189.68,66.37 189.86,66.37 190.88,67.38 191.06,67.38 191.72,66.72 191.72,66.54 191.54,66.36 191.54,66.21 191.03,65.7 191.03,65.7 190.71,65.37 190.51,65.17 190.33,65.17 189.3,66.2 189.12,66.2 188.94,66.02 188.94,65.84 189.97,64.81 189.97,64.63 189.79,64.45 188.59,64.45 188.46,64.58 188.46,65.93 188.38,66.01 188.05,66.01 187.95,65.92 187.95,64.58 187.83,64.45 177.95,64.45 177.14,63.64 174.24,63.64 174.09,63.49 174.09,63.2 173.96,63.07 173.23,63.07 173.1,62.94 173.1,62.69 173.23,62.56 173.96,62.56 174.09,62.43 174.09,61.14 v2(174.8,60.43)
SOC_RGMII_RXD2_R: length 10.1
  TOP w0.127: U92.28 173.97,56.56 174.8,57.39 R538.2 174.26,58.04 174.04,58.25 174.04,61.19 v2(174.8,61.95) R533.1
  BOTTOM w0.127: R533.1 v2(174.8,61.95)
SOC_RGMII_RXD3: length 89.8
  TOP w0.127: R532.1 v2(176.33,60.43) ; U1.F22 v1(178.81,111.41)
  L08_SIG2 w0.102: 189.1,107.62 189.07,107.62 188.49,108.21 186.45,108.21 185.31,109.35 185.31,109.6 184.73,110.17 183.34,110.17 183.08,109.92 181.28,109.92 180.16,111.04 180.16,111.58 179.92,111.83 178.94,111.83 178.81,111.69 v1(178.81,111.41)
  L08_SIG2 w0.127: v2(176.33,60.43) 176.91,59.85 176.91,59.2 176.66,58.94 175.89,58.94 175.77,59.07 175.77,62.4 176.12,62.75 177.55,62.75 178.26,63.46 178.53,63.46 178.72,63.65 179.04,63.65 179.22,63.46 179.54,63.46 179.73,63.65 180.05,63.65 180.24,63.46 180.56,63.46 180.75,63.65 181.07,63.65 181.26,63.46 181.58,63.46 181.76,63.65 182.08,63.65 182.27,63.46 182.59,63.46 182.78,63.65 183.1,63.65 183.29,63.46 183.61,63.46 183.8,63.65 184.12,63.65 184.3,63.46 184.62,63.46 184.81,63.65 185.13,63.65 185.32,63.46 185.64,63.46 185.83,63.65 186.15,63.65 186.34,63.46 186.66,63.46 186.84,63.65 187.16,63.65 187.35,63.46 187.67,63.46 187.86,63.65 188.18,63.65 188.37,63.46 188.69,63.46 188.88,63.65 189.2,63.65 189.38,63.46 190.93,63.46 192.95,65.48 192.95,66.42 194.64,68.11 194.64,68.24 194.43,68.45 194.43,68.75 194.64,68.96 194.64,69.26 194.43,69.47 194.43,69.76 194.64,69.98 194.64,70.27 194.43,70.48 194.43,70.78 194.64,70.99 194.64,71.29 194.43,71.5 194.43,71.8 194.64,72.01 194.64,72.3 194.43,72.52 194.43,72.81 194.64,73.02 194.64,73.32 194.43,73.53 194.43,73.83 194.64,74.04 194.64,74.34 194.43,74.55 194.43,74.84 194.64,75.06 194.64,75.47 194.43,75.68 194.43,75.98 194.64,76.19 194.64,76.48 194.43,76.7 194.43,76.99 194.64,77.21 194.64,77.5 194.43,77.71 194.43,78.01 194.64,78.22 194.64,78.52 194.43,78.73 194.43,79.02 194.64,79.24 194.64,79.53 194.43,79.75 194.43,80.04 194.64,80.25 194.64,88.99 193.52,90.11 193.52,91.2 192.76,91.96 192.76,92.95 193.09,93.28 193.09,95.46 192.84,95.72 192.41,95.72 192.28,95.84 192.28,96.1 192.41,96.23 192.84,96.23 192.96,96.35 192.96,101.26 192.48,101.74 192.48,104.54 190.12,106.9 190.11,106.9 189.39,107.62 189.1,107.62
SOC_RGMII_RXD3_R: length 11.4
  TOP w0.127: R531.1 v2(176.33,61.95) 175.56,61.19 175.56,58.25 175.78,58.04 R532.2 176.33,56.91 176.2,56.78 174.8,56.78 174.47,56.45 U92.27
  BOTTOM w0.127: R531.1 v2(176.33,61.95)
SOC_RGMII_TXCLK: length 15.6
  TOP w0.127: U1.C25 181.61,107 181.81,106.8 182.4,106.8 182.59,106.99 183.81,106.99 184.57,107.75 184.57,107.75 184.8,107.98 184.8,107.98 185.72,108.9 189.26,108.9 190.14,108.02 190.14,107.73 190.88,107 190.88,106.43 191.01,106.3 191.01,105.84 191.5,105.35 R449.1
SOC_RGMII_TXCLK_R: length 78.2
  TOP w0.127: R449.2 193.69,105.35 193.71,105.32 v2(194.16,105.32) ; U92.24 176.71,54.38 v2(177.09,54.75)
  L08_SIG2 w0.127: v2(194.16,105.32) 194.16,105.31 193.7,104.85 193.7,103.27 194.18,102.79 194.18,102.78 194.31,102.66 194.31,101.36 194.36,101.31 194.36,101.3 195.63,100.03 195.63,94.71 196.44,93.89 196.44,93.39 196.47,93.37 196.47,64.19 193.73,61.46 188.29,61.46 188.17,61.58 188.17,61.99 188.04,62.12 187.79,62.12 187.66,61.99 187.66,61.58 187.53,61.46 187.28,61.46 187.15,61.58 187.15,61.99 187.02,62.12 186.77,62.12 186.64,61.99 186.64,61.58 186.52,61.46 186.26,61.46 186.13,61.58 186.13,61.99 186.01,62.12 185.75,62.12 185.63,61.99 185.63,61.58 185.5,61.46 185.25,61.46 185.12,61.58 185.12,61.99 184.99,62.12 184.74,62.12 184.61,61.99 184.61,61.58 184.48,61.46 184.23,61.46 184.1,61.58 184.1,61.99 183.98,62.12 183.72,62.12 183.59,61.99 183.59,61.58 183.47,61.46 183.21,61.46 183.09,61.58 183.09,61.99 182.96,62.12 182.71,62.12 182.58,61.99 182.58,61.58 182.45,61.46 182.2,61.46 182.07,61.58 182.07,61.99 181.94,62.12 181.69,62.12 181.56,61.99 181.56,61.58 181.44,61.46 178.97,61.46 177.93,60.42 177.93,55.59 v2(177.09,54.75)
SOC_RGMII_TXCTL: length 11.6
  TOP w0.127: R465.1 182.38,101.38 182,101.75 182,101.79 179.67,104.13 179.39,104.13 177.61,105.91 U1.H25
SOC_RGMII_TXCTL_R: length 81.2
  TOP w0.127: v2(176.78,56.28) 176.34,55.83 175.76,55.83 175.47,55.55 U92.25 ; v2(184.02,99.16) 183.77,99.42 R465.2
  L08_SIG2 w0.127: v2(184.02,99.16) 184.02,99.68 183.9,99.81 183.67,99.81 183.54,99.94 183.54,100.19 183.67,100.32 183.9,100.32 184.02,100.45 184.02,100.88 184.15,101.01 184.4,101.01 184.53,100.87 184.53,99.94 184.78,99.68 185.04,99.68 185.17,99.81 185.17,100.12 185.29,100.24 187.68,100.24 188.47,99.46 188.47,98.95 187.91,98.39 187.91,92.68 189.31,91.28 189.31,84.52 190.34,83.48 190.34,83.34 190.22,83.21 189.93,83.21 189.8,83.08 189.8,82.83 189.93,82.7 190.22,82.7 190.34,82.57 190.34,82.32 190.22,82.19 189.93,82.19 189.8,82.07 189.8,81.81 189.93,81.69 190.22,81.69 190.34,81.56 190.34,81.3 190.22,81.18 189.93,81.18 189.8,81.05 189.8,80.8 189.93,80.67 190.22,80.67 190.34,80.54 190.34,80.29 190.22,80.16 189.93,80.16 189.8,80.03 189.8,79.78 189.93,79.65 190.22,79.65 190.34,79.53 190.34,77.67 191.44,76.57 191.44,76.26 191.31,76.14 190.78,76.14 190.65,76.01 190.65,75.75 190.78,75.63 191.31,75.63 191.44,75.5 191.44,75.25 191.31,75.12 190.78,75.12 190.65,74.99 190.65,74.74 190.78,74.61 191.31,74.61 191.38,74.55 191.38,73.32 191.44,73.25 191.44,72.02 190.46,71.04 190.45,71.04 190.05,70.64 190.05,70.63 189.74,70.32 189.73,70.32 189.33,69.92 189.33,69.91 189.02,69.61 189.01,69.61 188.61,69.2 188.61,69.19 188.3,68.89 188.29,68.89 187.89,68.48 187.89,68.47 187.58,68.17 187.57,68.17 187.17,67.77 187.17,67.76 186.87,67.45 186.86,67.45 186.45,67.05 186.45,67.04 186.15,66.73 186.14,66.73 185.73,66.33 185.73,66.32 184.68,65.27 177.37,65.27 176.58,64.48 172.47,64.48 171.2,63.21 171.2,60.12 172.57,58.74 174.76,58.74 176.78,56.72 v2(176.78,56.28)
SOC_RGMII_TXD0: length 20.5
  TOP w0.127: U1.G23 v1(178.01,110.61) ; v2(190.42,103.67) 190.42,102.75 190.85,102.33 R445.1
  L08_SIG2 w0.102: v1(178.01,110.61) 178.22,110.61 178.61,110.23 179.98,110.23 181.09,109.12 182.99,109.12 183.96,108.15 183.96,108 185.04,106.92 185.04,104.39 185.41,104.03
  L08_SIG2 w0.127: v2(190.42,103.67) 189.98,103.67 189.95,103.7 189.79,103.7 188.85,102.76 186.59,102.76 185.48,103.87 185.48,103.96 185.41,104.03
SOC_RGMII_TXD0_R: length 73.2
  TOP w0.127: U92.19 177.52,51.88 v2(177.98,52.34) ; R445.2 193.7,102.33 193.98,102.61 193.98,103.06 v2(194.64,103.72)
  L08_SIG2 w0.127: v2(194.64,103.72) 194.64,103.65 195.28,103.01 195.28,101.47 196.39,100.35 196.39,95.24 197.56,94.07 197.56,64.23 197.23,63.9 197.23,63.87 194.06,60.7 194.03,60.7 193.78,60.44 180.62,60.44 179.58,59.4 179.58,53.86 178.75,53.04 178.75,53.03 178.26,52.54 178.25,52.54 178.05,52.34 v2(177.98,52.34)
SOC_RGMII_TXD1: length 14.7
  TOP w0.127: R467.1 186.52,101.38 185.75,102.15 185.39,102.15 185.17,102.37 185.17,102.37 184.91,102.63 182.24,102.63 180.49,104.38 180.48,104.38 179.96,104.9 179.64,104.9 178.81,105.74 178.81,109.81 U1.G24
SOC_RGMII_TXD1_R: length 78.9
  TOP w0.127: R467.2 187.07,99.43 186.87,99.23 186.87,99.2 186.86,99.2 v2(186.86,99.2) ; U92.20 v2(176.9,52.38)
  L08_SIG2 w0.127: v2(186.86,99.2) 186.86,99.2 186.87,99.2 186.87,98.8 187.1,98.57 187.1,98.18 186.97,98.06 186.06,98.06 185.93,98.19 185.93,98.47 185.83,98.57 185.45,98.57 185.32,98.44 185.32,98.24 185.14,98.06 184.51,98.06 184.38,97.93 184.38,97.67 184.51,97.55 185.35,97.55 185.47,97.42 185.47,96.46 185.6,96.33 185.86,96.33 185.98,96.46 185.98,97.42 186.11,97.55 186.97,97.55 187.1,97.42 187.1,96.2 186.97,96.08 186.19,96.08 186.06,95.95 186.06,95.7 186.19,95.57 186.97,95.57 187.1,95.44 187.1,92.03 186.92,91.85 186.92,86.91 188.06,85.77 188.06,83.1 188.85,82.31 188.85,79.43 189.39,78.89 189.39,76.59 189.4,76.58 189.4,72.49 183.34,66.44 179.2,66.44 178.79,66.84 178.54,66.84 178.51,66.87 170.54,66.87 169.65,65.98 169.65,60.11 173.18,56.58 173.2,56.58 173.71,56.07 173.71,55.56 v2(176.9,52.38)
SOC_RGMII_TXD2: length 12.5
  TOP w0.127: U1.G25 178.41,105.64 179.46,104.59 179.78,104.59 182.12,102.25 184.52,102.25 185.29,101.48 R466.1
SOC_RGMII_TXD2_R: length 81.2
  TOP w0.127: v2(185.62,99.05) 185.29,99.38 R466.2 ; v2(177.91,53.38) 177.41,52.88 U92.21
  L08_SIG2 w0.127: v2(177.91,53.38) 177.33,53.96 176.4,53.96 175.97,54.4 175.97,56.2 173.81,58.36 172.42,58.36 170.81,59.96 170.81,65.47 171.83,66.49 178.35,66.49 178.38,66.46 178.49,66.46 179.04,65.9 184.1,65.9 190.33,72.14 190.33,74.45 189.78,75.01 189.78,76.74 189.77,76.74 189.77,79.05 189.41,79.41 189.41,82.51 188.85,83.07 188.85,86.76 188.72,86.89 187.65,86.89 187.52,87.01 187.52,87.27 187.65,87.39 188.72,87.39 188.85,87.52 188.85,87.78 188.72,87.9 187.52,87.9 187.39,88.03 187.39,88.28 187.52,88.41 188.72,88.41 188.85,88.54 188.85,88.79 188.72,88.92 187.39,88.92 187.3,89.01 187.3,89.33 187.39,89.43 188.72,89.43 188.85,89.55 188.85,91.2 187.5,92.55 187.5,98.67 187.48,98.69 187.48,98.72 187.31,98.89 187.31,99.67 187.15,99.84 186.26,99.84 185.6,99.18 185.6,99.07 185.62,99.05 185.62,99.05 v2(185.62,99.05)
SOC_RGMII_TXD3: length 18
  TOP w0.127: U1.D25 180.81,107.14 181.38,106.57 183.19,106.57 183.3,106.68 183.96,106.68 185.9,108.63 189,108.63 189.71,107.91 189.71,107.69 189.72,107.68 189.72,107.66 190.52,106.85 190.52,106.21 190.65,106.09 190.65,105.12 190.42,104.89 190.42,104.32 190.92,103.82 R453.1
SOC_RGMII_TXD3_R: length 75.2
  TOP w0.127: U92.22 v2(176.9,53.38) ; v2(194.49,104.54) 193.78,103.82 R453.2
  L08_SIG2 w0.127: v2(194.49,104.54) 194.08,104.13 194.08,103.43 194.56,102.95 194.56,102.94 194.69,102.81 194.69,102.81 194.74,102.76 194.74,101.46 196.01,100.19 196.01,94.99 197.18,93.82 197.18,68.09 197.05,67.96 197.03,67.96 196.9,67.83 196.9,67.58 197.03,67.45 197.05,67.45 197.18,67.33 197.18,67.05 197.05,66.92 196.92,66.92 196.85,66.85 196.85,66.48 196.92,66.41 197.05,66.41 197.18,66.28 197.18,66.03 197.05,65.9 196.92,65.9 196.85,65.84 196.85,65.46 196.92,65.4 197.05,65.4 197.18,65.27 197.18,65.01 197.05,64.89 196.92,64.89 196.85,64.82 196.85,64.02 193.9,61.08 193.85,61.08 193.6,60.82 179.34,60.82 178.41,59.89 178.41,55.54 178.92,55.03 178.92,53.74 178.37,53.19 178.37,53.19 178.1,52.92 178.1,52.92 178.06,52.88 177.39,52.88 v2(176.9,53.38)
SOC_SPI0_CLK: length 172
  TOP w0.127: R373.1 v2(175.89,146.11)
  L08_SIG2 w0.127: v2(175.89,146.11) 175.89,151.27 176.43,151.81 176.43,159.53 209.44,192.55 217.3,192.55 221.11,196.36 v2(221.11,197.26)
  BOTTOM w0.127: J12.13 298.77,220.54 298.77,218.64 297.43,217.31 297.43,212.01 294.79,209.37 294.79,205.6 292.28,203.09 290.11,203.09 288.71,201.69 278.59,201.69 277.15,203.13 235.26,203.13 229.39,197.26 v2(221.11,197.26)
SOC_SPI0_MISO: length 196.7
  TOP w0.127: v1(174.01,132.42) 174.41,132.02 U1.M1
  L08_SIG2 w0.102: 173.81,134.1 173.61,133.9 173.61,132.82 v1(174.01,132.42)
  L08_SIG2 w0.127: 173.81,134.1 173.94,134.23 173.94,138.22 173.56,138.6 173.56,140.93 174.9,142.28 174.9,151.04 176.02,152.16 176.02,159.67 209.28,192.93 216.66,192.93 220.6,196.86 v2(220.6,199.15)
  BOTTOM w0.127: J12.9 298.8,226.81 296.57,224.58 296.57,212.39 293.93,209.75 293.93,205.96 291.96,204 289.8,204 289.19,203.39 278.11,203.39 277.51,203.99 234.71,203.99 228.92,198.2 221.11,198.2 220.6,198.71 v2(220.6,199.15)
SOC_SPI0_MOSI: length 202.4
  TOP w0.127: U1.N4 v1(174.01,125.81)
  L08_SIG2 w0.102: v1(174.01,125.81) 174.01,126.01 173.61,126.41 173.61,126.86 173.44,127.03 173.05,127.03 172.83,127.26 172.83,128.23 171.78,129.28 171.78,130.39 171.98,130.6 171.98,131.96 171.83,132.11 171.83,132.18 171.82,132.18 171.82,132.62 171.82,132.63 171.82,132.81 171.83,132.82 171.83,132.91 172.31,133.39 172.31,134.63 172.49,134.81 172.49,134.89
  L08_SIG2 w0.127: 172.49,134.89 172.49,137.69 172.16,138.02 172.16,141.7 172.21,141.75 172.21,147.49 171.46,148.24 171.46,157.51 191.12,177.17 191.12,180.11 204.45,193.44 215.39,193.44 v2(219.33,197.37)
  BOTTOM w0.127: v2(219.33,197.37) 219.77,197.82 220.66,197.82 220.76,197.72 229.31,197.72 235.1,203.51 277.31,203.51 278.71,202.11 282.24,202.11 282.77,202.64 289.12,202.64 290,203.51 292.16,203.51 294.41,205.76 294.41,209.53 297.05,212.17 297.05,223.79 297.53,224.27 J12.11
SOC_SPI0_SCS0: length 194.7
  TOP w0.127: U1.M3 v1(174.01,127.41)
  L08_SIG2 w0.102: 172.6,134.59 172.77,134.76 ; 172.03,132.72 172.03,132.59 172.03,132.58 172.03,132.27 172.03,132.26 172.03,132.2 172.8,131.43 172.8,130.86 172.02,130.09 172.02,129.41 173.78,127.65 173.78,127.64 v1(174.01,127.41)
  L08_SIG2 w0.127: v2(220.09,197.37) 215.89,193.17 209.18,193.17 209.17,193.16 204.56,193.16 191.4,180 191.4,176.81 173.93,159.34 173.93,146.4 173.23,145.7 173.23,142.38 172.44,141.59 172.44,138.13 172.6,137.97 172.77,137.8 172.77,134.76 ; 172.6,134.59 172.6,133.28 172.03,132.72
  BOTTOM w0.127: v2(220.09,197.37) 220.73,196.74 229.41,196.74 235.42,202.75 277,202.75 278.43,201.31 291.04,201.31 295.17,205.45 295.17,209.21 297.81,211.85 297.81,217.05 J12.15
SOC_SPI0_SCS1: length 202.7
  TOP w0.127: U1.M4 v1(174.81,125.81)
  L08_SIG2 w0.102: 174.62,134.25 174.62,127.98 174.42,127.78 174.42,126.2 v1(174.81,125.81)
  L08_SIG2 w0.127: v2(221.68,198.64) 221.68,195.91 217.93,192.17 209.6,192.17 176.81,159.38 176.81,145.81 177.5,145.13 177.5,141.62 176.91,141.04 176.91,140.1 174.52,137.71 174.52,134.36 174.62,134.25
  BOTTOM w0.127: J12.10 301.43,227.86 299.51,227.86 296.33,224.68 296.33,212.65 295.59,211.91 294.32,211.91 293.69,211.28 293.69,206.17 291.76,204.24 289.7,204.24 289.09,203.63 278.21,203.63 277.48,204.36 234.57,204.36 228.85,198.64 v2(221.68,198.64)
SOC_SPI1_CLK: length 12
  TOP w0.127: U1.N2 173.21,128.21 173.21,135.17 v1(175.56,137.53)
  BOTTOM w0.127: v1(175.56,137.53) 175.89,137.86 R715.2
SOC_SPI1_CLK_R: length 56.7
  TOP w0.127: v2(192.76,177.59) 192.76,178.12 193.21,178.58 U40.16
  L03_SIG1 w0.127: v2(175.89,141.97) 175.89,141.44 177.37,139.97 179.4,139.97 180.47,141.04 180.47,146.21 181.57,147.31 189.05,147.31 190.63,148.88 190.63,164.96 192.76,167.09 v2(192.76,177.59)
  BOTTOM w0.127: R715.1 v2(175.89,141.97)
SOC_SPI1_MISO: length 73.9
  TOP w0.127: v2(201.8,187.59) 202.39,187.59 202.51,187.47 U40.8 ; v1(174.01,131.15) 173.61,130.75 U1.N1
  L08_SIG2 w0.102: v1(174.01,131.15) 173.35,131.81 173.35,134.15
  L08_SIG2 w0.127: v2(201.8,187.59) 202.3,187.1 202.3,186.3 202.01,186.01 201.99,186.01 175.51,159.53 175.51,154.7 174.66,153.85 174.66,142.38 173.28,140.99 173.28,138.48 173.66,138.1 173.66,134.53 173.35,134.23 173.35,134.15
SOC_SPI1_MOSI: length 62.6
  TOP w0.127: U1.P2 172.41,128.21 v1(172.41,129.88) ; v2(192.79,179.85) U40.15
  L08_SIG2 w0.102: v1(172.41,129.88) 173.1,130.58 173.1,134.36 173.38,134.63 173.38,134.89
  L08_SIG2 w0.127: 173.38,134.89 173.38,137.98 173,138.37 173,141.06 174.42,142.48 174.42,158.94 192.15,176.67 192.15,179.21 v2(192.79,179.85)
SOC_SPI1_SCS0: length 77.9
  TOP w0.127: U1.P1 172.81,132.02 v1(172.41,132.42) ; v2(201.8,186.5) 202.11,186.2 U40.7 205.13,186.2 205.18,186.15 R333.2
  L08_SIG2 w0.102: v1(172.41,132.42) 172.87,132.89 172.87,134.53 173.1,134.76 173.1,134.89
  L08_SIG2 w0.127: v2(201.8,186.5) 198.3,186.5 191.77,179.97 191.77,176.78 174.18,159.2 174.18,142.58 172.72,141.12 172.72,138.25 173.1,137.87 173.1,134.89
SOC_SPI2_CLK: length 145.7
  L03_SIG1 w0.127: v2(190.42,140.66) 190.81,140.66 191.16,140.31 199.91,140.31 200.89,139.33 206.25,139.33 207.21,140.3 233.74,140.3 236.01,140.3 239.49,136.82 251.61,136.82 256.17,132.26 270.3,132.26 274.66,136.62 274.97,136.62 295.82,136.62 298.91,133.52 JP1.9
  BOTTOM w0.127: R716.1 170.42,139.86 170.56,139.71 170.56,134.76 171.37,133.95 172.26,133.95 175.05,136.74 182.73,136.74 184.51,138.52 184.82,138.52 185.03,138.72 186.49,138.72 187.66,139.89 189.13,139.89 189.9,140.66 v2(190.42,140.66)
SOC_SPI2_MISO: length 147.8
  TOP w0.127: U1.R4 v1(172.41,126.61)
  L03_SIG1 w0.127: JP1.16 301.45,124.84 299.13,124.84 288.29,135.68 276.24,135.68 271.91,131.35 255.54,131.35 251.08,135.8 239.18,135.8 236.54,138.44 207.53,138.44 207.36,138.27 196.74,138.27 196.47,138.55 194.28,138.55 194.01,138.27 v2(193.24,138.27)
  BOTTOM w0.127: v1(172.41,126.61) 172.64,126.84 172.65,126.84 172.8,126.99 172.8,127.24 172.8,127.25 172.8,127.58 172.8,127.58 172.8,129.3 172.84,129.35 172.84,130.16 173.51,130.82 173.51,131.41 173.89,131.79 174.7,131.79 175.18,132.27 175.18,132.6 175.43,132.86 177.29,132.86 178.61,134.18 184.22,134.18 186.2,136.16 188.8,136.16 190.51,137.87 192.83,137.87 v2(193.24,138.27)
SOC_SPI2_MOSI: length 145.4
  TOP w0.127: U1.R3 v1(172.41,127.41)
  L03_SIG1 w0.127: JP1.15 298.91,125.9 288.86,135.96 275.59,135.96 271.26,131.63 255.77,131.63 251.31,136.08 239.3,136.08 235.79,139.59 208.03,139.59 207.01,138.57 197.28,138.57 197.02,138.84 194.16,138.84 194.07,138.93 v2(193.62,138.93)
  BOTTOM w0.102: 176.68,133.14 177.21,133.14 178.56,134.48 182.01,134.48 ; 171.98,127.85 v1(172.41,127.41)
  BOTTOM w0.127: 176.68,133.14 175.31,133.14 175.03,132.86 173.83,132.86 173.23,132.25 173.23,131.29 171.98,130.04 171.98,127.85 ; 182.01,134.48 184.18,134.48 186.13,136.44 188.72,136.44 190.47,138.19 192.2,138.19 192.94,138.93 v2(193.62,138.93)
SOC_SPI2_SCS0: length 142.6
  TOP w0.127: U1.P3 v1(173.21,127.41) ; v2(182.31,133.56) 185.19,136.44 186.48,136.44 186.6,136.57 195.5,136.57 195.68,136.74 202.16,136.74 203.07,137.66 v2(208.1,137.66)
  L03_SIG1 w0.127: JP1.17 288,135.34 276.86,135.34 272.58,131.07 255.31,131.07 251.05,135.32 239.06,135.32 238.15,136.24 218.41,136.24 216.99,137.66 v2(208.1,137.66)
  BOTTOM w0.102: v1(173.21,127.41) 173.21,130.12 173.66,130.58 174.09,130.58 175.36,131.85 177.22,131.85 178.62,133.24 178.97,133.24
  BOTTOM w0.127: v2(182.31,133.56) 182,133.24 178.97,133.24
SOC_SPI3_CLK: length 114.5
  TOP w0.127: v2(189.53,102.55) 189.71,102.38 189.71,102.21 189.81,102.1 189.81,102.1 190.75,101.16 193.93,101.16 196.86,104.09 R450.2 ; U79.6 v2(108.77,86.37)
  L03_SIG1 w0.127: v2(108.77,86.37) 117.02,78.12 153.29,78.12 157.25,82.08 157.25,89.6 163.68,96.03 164.47,96.03 166.27,97.83 168.81,97.83 170.38,99.41 170.38,100.53 170.41,100.56 170.41,101.15 171.88,102.62 172.1,102.62 172.49,103.01 173.79,103.01 174.45,103.67 175.08,103.67 175.77,102.99 176.38,102.99 176.61,102.76 178.24,101.13 183.75,101.13 184.95,102.33 189.31,102.33 v2(189.53,102.55)
SOC_SPI3_MISO: length 18.3
  TOP w0.127: U1.F25 179.21,105.77 179.81,105.17 180.09,105.17 180.87,104.38 180.99,104.38 182.36,103.01 185.07,103.01 185.55,102.53 185.94,102.53 186.3,102.16 189.22,102.16 189.69,101.69 189.69,100.6 189.98,100.31 TP159.1
SOC_SPI3_MOSI: length 96.6
  TOP w0.127: v1(179.61,108.14) 179.61,109.81 U1.F24 ; U79.7 v2(109.42,87.14)
  L03_SIG1 w0.127: v1(179.61,108.14) 179.31,107.85 179.31,107.58 177.84,106.11 173.12,106.11 171.83,104.82 169.35,104.82 169.34,104.83 168.99,104.83 168.74,104.58 168.74,104.55 168.72,104.52 168.72,104.02 163.78,99.07 163.04,99.07 162.43,98.47 159.41,98.47 159,98.06 159,92.62 156.59,90.21 156.59,82.56 154.25,80.22 116.33,80.22 v2(109.42,87.14)
SOC_SPI3_SCS0: length 99.2
  TOP w0.127: U1.C24 182.02,109.81 182.02,107.28 182.05,107.24 v1(182.05,107.21)
  L03_SIG1 w0.102: v1(182.05,107.21) 180.65,107.21 178.19,104.75 173.09,104.75 172.82,104.49 172.82,104.03
  L03_SIG1 w0.127: v2(108.08,87.14) 108.71,87.14 115.98,79.87 154.43,79.87 156.87,82.32 156.87,89.83 163.98,96.94 163.98,97.37 165.25,98.64 168.88,98.64 170,99.76 170,100.69 170.03,100.71 170.03,101.31 171.72,103 171.94,103 172.76,103.82 172.82,103.88 172.82,104.03
  BOTTOM w0.127: R828.1 107.36,86.87 107.63,87.14 v2(108.08,87.14)
SOC_SPI3_SCS0_R: length 1.9
  TOP w0.127: U79.5 v2(107.33,88.77)
  BOTTOM w0.127: v2(107.33,88.77) 106.72,88.17 R828.2
SOC_SYSCLKN: length 36
  TOP w0.102: R22.2 151.02,84.74 151.24,84.96 152.59,84.96 v2(152.91,84.63) ; U1.AC25 165.37,109.18 165.37,107.22 165.71,106.88 165.71,105.68 v1(165.91,105.48)
  L03_SIG1 w0.102: v2(152.91,84.63) 153.32,85.04 154.24,85.04 154.8,85.6 154.8,92 156.22,93.43 156.22,99.09 157.79,100.66 162.11,100.66 165.66,104.21 165.66,105.22 v1(165.91,105.48)
SOC_SYSCLKP: length 36
  TOP w0.102: v2(152.91,85.61) 152.59,85.29 151.18,85.29 151.02,85.45 R21.2 ; v1(165.14,105.45) 164.84,105.75 164.84,106.01 165,106.16 165.3,106.16 165.38,106.24 165.38,106.75 165.04,107.08 165.04,109.18 U1.AD25
  L03_SIG1 w0.102: v1(165.14,105.45) 165.39,105.2 165.39,104.32 162,100.93 157.68,100.93 155.96,99.2 155.96,93.54 154.53,92.12 154.53,85.71 154.13,85.31 153.22,85.31 v2(152.91,85.61)
SOC_SYSCLKSEL: length 220.8
  TOP w0.127: U33.14 64.48,175.92 64.39,176.02 R262.2 64.39,177.29 v2(65.41,177.29) 66.04,176.66 66.04,174.77 66.55,174.26 66.55,171.57 74.63,163.49 94.28,163.49 110.07,179.28 110.07,187.49 111.12,188.55 111.12,199.19 109.6,200.71 109.6,204.83 117.13,212.36 117.81,212.36 121.39,212.36 136.8,196.94 146.52,196.94 161.23,182.23 161.23,178.77 170.69,169.31 172.08,169.31 v2(172.59,169.81) ; v1(172.41,131.15) 172.01,130.75 U1.R1
  L03_SIG1 w0.102: v1(172.41,131.15) 172.41,131.68 173.2,132.48 173.2,134.89
  L03_SIG1 w0.127: v2(172.59,169.81) 172.59,166.26 173.94,164.91 173.94,148.23 173.22,147.51 173.22,142.22 172.01,141.01 172.01,138.19 173.2,137 173.2,134.89
  BOTTOM w0.127: R262.2 64.39,177.29 v2(65.41,177.29)
SOC_TCK: length 85.6
  TOP w0.127: v2(220.75,109.51) 221.04,109.23 U134.4 ; U1.L3 v1(174.81,127.41)
  L03_SIG1 w0.102: v2(175.29,134.71) 175.01,134.43 175.01,127.61 v1(174.81,127.41)
  L03_SIG1 w0.127: v2(220.75,109.51) 216.56,113.71 211.92,113.71 211.9,113.72 211.75,113.72 v2(211.56,113.91)
  BOTTOM w0.127: v2(211.56,113.91) 211.43,114.04 211.43,125.01 210.86,125.58 210.86,137.9 206.86,141.9 195.3,141.9 193.85,140.45 192.09,140.45 191.36,139.71 190.12,139.71 188.16,137.76 185.48,137.76 183.45,135.73 176.48,135.73 175.78,135.03 175.6,135.03 v2(175.29,134.71)
SOC_TDI: length 87.6
  TOP w0.127: v2(218.49,107.43) 218.65,107.59 R336.2 220.61,107.59 220.93,107.28 U134.7 ; U1.L5 v1(175.61,125.81)
  L03_SIG1 w0.102: v1(175.61,125.81) 176.02,126.23 176.53,126.23 176.54,126.23 176.57,126.23 176.79,126.46 176.79,126.77 176.78,126.78 177.01,127.01 177.34,127.01 177.36,127.03 177.37,127.03 177.59,127.26 177.59,127.26 177.6,127.27 177.6,129.05 178.31,129.76 178.31,134.13 179.07,134.89
  L03_SIG1 w0.127: v2(218.49,107.43) 218.08,107.84 215.57,107.84 211.02,112.38 v2(211.02,112.6) ; 179.07,134.89 181.1,136.92 181.1,137.78 182.35,139.03 183.6,139.03 184.97,140.4 187.76,140.4 188.2,139.96 189.06,139.96 190.25,141.14 193.05,141.14 193.21,140.98 193.59,140.98 193.74,141.14 195.66,141.14 v2(195.88,140.91)
  BOTTOM w0.127: v2(195.88,140.91) 196.33,140.91 196.51,141.09 206.44,141.09 210.13,137.4 210.13,124.78 210.72,124.2 210.72,116.55 210.34,116.17 210.34,113.39 211.02,112.71 v2(211.02,112.6)
SOC_TDO: length 26.2
  TOP w0.127: v2(186.64,139.92) 186.79,139.77 186.79,138.71 185.64,137.56 R328.2 185.59,137.51 186.28,137.51 186.4,137.62 U59.3 ; U1.K5 v1(176.41,125.81)
  L03_SIG1 w0.102: v1(176.41,125.81) 176.62,126.03 176.65,126.03 176.85,126.23 177.44,126.23 177.62,126.41 177.62,126.79 177.87,127.03 178.17,127.03 178.4,127.26 178.4,129.39 179.32,130.32 179.32,134.62 179.59,134.89
  L03_SIG1 w0.127: 179.59,134.89 181.48,136.78 181.48,137.4 181.76,137.68 183.97,137.68 184.81,138.52 184.82,138.52 185.09,138.79 185.09,138.81 186.19,139.92 v2(186.64,139.92)
SOC_TIMI1: length 255.1
  TOP w0.127: U1.W23 v1(168.41,110.61) ; v2(294.89,167.15) 294.89,173.12 296.28,174.5 296.28,175.85 297.51,177.08 297.51,209.34 298.42,210.25 301.17,210.25 J12.22
  L03_SIG1 w0.127: v2(229.23,132.09) 229.97,132.83 252.96,132.83 255,130.79 273,130.79 277.28,135.06 279.52,135.06 v2(279.83,134.75) ; v2(230.33,113.5) 230.33,112.94 229.79,112.41 229.79,106.47 227.94,104.61 221.36,104.61 212.03,95.28 208.97,95.28 207.76,94.07 205.95,94.07 205.64,93.77 196.44,93.77 195.3,94.91 192.32,94.91 188.47,98.76 188.47,99.92 190.09,101.54 190.09,102.86 189.69,103.27 188.98,103.27 188.76,103.05 185.75,103.05 183.9,104.9 183.9,106.69 182.97,107.62 181.88,107.62 181.86,107.6 179.74,107.6 179.19,107.05 179.19,107.04 177.36,105.21 172.9,105.21 172.89,105.2 172.67,105.2 172.19,104.71 172.19,104.1 171.7,103.62 169.49,103.62 169.16,103.95 v1(169.16,104.41)
  BOTTOM w0.127: 168.94,106.06 168.94,106.06 ; 168.94,106.06 168.94,104.64 v1(169.16,104.41) ; 168.94,106.06 168.94,106.74 168.98,106.78 168.98,109.4 168.41,109.98 v1(168.41,110.61) ; v2(229.23,132.09) 229.23,130.57 230.02,129.78 230.02,113.93 230.33,113.63 v2(230.33,113.5) ; v2(294.89,167.15) 291.08,163.34 291.08,146 v2(279.83,134.75)
SOC_TIMO1: length 254.1
  TOP w0.127: v1(168.27,104.41) 168.01,104.67 U1.Y25
  L03_SIG1 w0.102: v1(168.27,104.41) 168.27,104.69 168.76,105.17 171.86,105.17 173.13,106.44 176.94,106.44 179.07,108.57 182.97,108.57 183.07,108.47 183.99,108.47 184.13,108.61 184.48,108.61 184.57,108.52 188.42,108.52 189.1,107.84
  L03_SIG1 w0.127: v2(227.84,112.16) 228.32,111.67 228.32,106.31 227.46,105.45 221.77,105.45 220.93,106.29 218.72,106.29 217.58,105.15 217.58,102.53 212.85,97.81 212.85,97.62 211.52,96.28 208.29,96.28 207.08,95.07 205.36,95.07 205.24,94.96 197.13,94.96 195.81,96.28 192.66,96.28 191.39,97.55 191.39,105.56 189.1,107.84
  BOTTOM w0.127: J12.24 303.67,207.84 303.67,175.24 291.46,163.03 291.46,145.74 271.91,126.18 243.98,126.18 237.59,132.56 231.22,132.56 231.2,132.55 228.28,132.55 227.89,132.16 227.89,131.78 228.04,131.63 228.04,112.36 v2(227.84,112.16)
SOC_TMS: length 94.3
  TOP w0.127: R343.2 230.73,107.23 229.38,108.58 U134.12 226.61,108.58 v2(226.54,108.65) ; U1.K4 v1(175.61,126.61)
  L03_SIG1 w0.102: v2(176.66,134.76) 176.66,134.46 176.26,134.06 176.26,130.12 176,129.86 176,127 v1(175.61,126.61)
  L03_SIG1 w0.127: v2(210.87,113.98) 211.25,114.37 211.86,114.37 212.14,114.09 218.16,114.09 223.29,108.96 226.24,108.96 v2(226.54,108.65)
  BOTTOM w0.102: 176.78,134.89 v2(176.66,134.76)
  BOTTOM w0.127: v2(210.87,113.98) 211.02,114.14 211.02,124.45 210.44,125.03 210.44,137.68 206.72,141.4 195.44,141.4 194.11,140.07 192.25,140.07 191.52,139.33 190.5,139.33 190.36,139.19 190.06,139.19 188.31,137.44 185.72,137.44 183.62,135.35 177.24,135.35 176.78,134.89
SOC_TRST#: length 98.5
  TOP w0.127: R319.2 230.82,105.6 229.92,105.6 228.89,106.63 U134.9 227.17,106.63 227.1,106.69 v2(226.57,106.69) ; U1.L4 v1(174.81,126.61)
  L03_SIG1 w0.102: v1(174.81,126.61) 175.21,127.01 175.21,133.95 175.77,134.51 175.77,134.89
  L03_SIG1 w0.127: v2(226.57,106.69) 227,107.13 227,108.89 225.64,110.25 222.71,110.25 218.34,114.62 v2(212.27,114.62) ; v2(175.56,135.57) 175.56,135.47 175.77,135.27 175.77,134.89
  BOTTOM w0.127: v2(212.27,114.62) 211.81,115.08 211.81,125.39 211.28,125.92 211.28,138.11 206.96,142.43 195.28,142.43 193.75,140.91 191.69,140.91 190.98,140.2 190.2,140.2 188.04,138.04 185.22,138.04 185.08,137.9 184.76,137.9 182.99,136.12 176.11,136.12 v2(175.56,135.57)
SOC_UART0_CP2105_EN: length 53.6
  TOP w0.127: U86.4 v2(13.19,42.93) ; U146.2 v2(23.29,88.91)
  L03_SIG1 w0.127: v2(23.29,88.91) 18.42,84.04 18.42,60.24 13.19,55.02 v2(13.19,42.93)
SOC_UART0_CTSN: length 196.8
  TOP w0.127: U1.T2 170.81,128.21 v1(170.81,129.88)
  L08_SIG2 w0.102: v1(170.81,129.88) 171.22,130.3 171.22,131.84 171.4,132.02 171.4,134.04 171.15,134.29 171.15,134.89
  L08_SIG2 w0.127: 171.15,134.89 171.15,134.97 170.99,135.12 170.99,135.92 170.97,135.95 170.97,135.97 170.81,136.12 170.81,137.94 171.7,138.83 171.7,141.37 171.21,141.86 171.21,143.13 171.73,143.65 171.73,143.69 171.74,143.7 171.74,147.56 171.18,148.12 171.18,157.74 190.84,177.4 190.84,180.23 204.33,193.72 214.91,193.72 v2(218.57,197.37)
  BOTTOM w0.127: v2(218.57,197.37) 219.46,196.48 229.55,196.48 235.57,202.5 276.9,202.5 278.34,201.06 291.12,201.06 295.41,205.35 295.41,208.94 298.07,211.6 298.07,216.26 299.51,217.7 301,217.7 J12.16
SOC_UART0_RTSN: length 194.3
  TOP w0.127: v1(170.81,131.15) 170.41,130.75 U1.U1
  L08_SIG2 w0.102: 170.79,134.89 170.79,134.3 171.2,133.9 171.2,132.15 170.81,131.76 v1(170.81,131.15)
  L08_SIG2 w0.127: v2(217.8,197.37) 214.43,193.99 204.22,193.99 190.56,180.34 190.56,177.62 170.9,157.96 170.9,148.01 171.46,147.45 171.46,143.82 170.69,143.04 170.69,141.87 171.32,141.24 171.32,139.21 170.54,138.42 170.54,136.01 170.69,135.85 170.69,135.83 170.71,135.81 170.71,134.99 170.79,134.91 170.79,134.89
  BOTTOM w0.127: J12.18 301.25,215.41 299.76,215.41 298.58,214.23 298.58,211.72 295.66,208.8 295.66,205.25 291.21,200.8 278.26,200.8 276.8,202.26 235.73,202.26 229.71,196.24 218.94,196.24 v2(217.8,197.37)
SOC_UART0_RXD: length 586.5
  TOP w0.127: J12.14 301.25,220.49 298.35,220.49 296.82,218.96 296.82,178.55 293.8,175.53 v2(293.8,174.46) ; v2(33.27,90.06) 33.53,90.31 33.53,91.08 33.35,91.26 U147.9 ; v2(20.24,91.69) 20.5,91.44 21.27,91.44 21.44,91.61 U146.9 ; U1.T4 v1(170.81,125.81)
  L03_SIG1 w0.127: v2(223.28,134) 221.4,135.88 208.48,135.88 207.87,136.49 206.38,136.49 206.1,136.77 197.15,136.77 195.76,138.17 195,138.17 194.55,137.72 187.24,137.72 184.07,134.55 184.07,133.47 182.96,132.35 v2(182.12,132.35) ; v2(33.27,90.06) 33.59,90.37 53.91,90.37 58.29,85.99 104.22,85.99 v2(104.8,86.58)
  BOTTOM w0.102: 173.59,128.42 173.59,126.46 173.36,126.23 171.22,126.23 v1(170.81,125.81) 170.42,126.2 166.55,126.2 166.39,126.36 166.39,127.88 165.73,128.54 165.73,130.57 164.26,132.04 164.26,134.89
  BOTTOM w0.127: 164.26,134.89 164.26,139.6 163.13,140.73 157.1,140.73 155.57,142.25 155.57,146.69 165.24,156.35 165.24,178.77 149.97,194.05 128,194.05 125.97,196.08 125.97,208.03 121.44,212.56 114.07,212.56 113.18,211.67 113.18,199.79 111.43,198.03 111.43,189.7 109.22,187.49 109.22,160.42 103.99,155.18 103.99,99.38 106.45,96.92 106.45,91.64 104.5,89.69 104.5,86.71 104.62,86.58 v2(104.8,86.58) ; v2(20.24,91.69) 20.45,91.49 26.64,91.49 28.07,90.06 v2(33.27,90.06) ; v2(293.8,174.46) 289.08,169.74 289.08,146.7 270.11,127.74 245.02,127.74 238.63,134.13 223.85,134.13 223.72,134 v2(223.28,134) ; v2(182.12,132.35) 181.8,132.66 179.89,132.66 178.81,131.59 175.43,131.59 174.16,130.32 173.86,130.32 173.58,130.03 173.58,128.43 173.59,128.42
SOC_UART0_TXD: length 512.1
  TOP w0.127: U146.8 21.41,92.01 21.39,92 21.2,92 v2(21.13,91.93) ; U147.8 32.95,91.22 32.97,91.2 32.97,91.01 v2(33.03,90.95) ; v1(170.81,132.42) 171.21,132.02 U1.T1
  L03_SIG1 w0.127: v2(33.03,90.95) 33.35,90.63 54.14,90.63 58.12,86.65 v2(103.81,86.65)
  L08_SIG2 w0.102: 170.43,134.89 170.43,133.86 170.43,133.85 170.43,133.54 170.43,133.53 170.43,133.36 170.81,132.99 v1(170.81,132.42)
  L08_SIG2 w0.127: v2(217.04,197.37) 213.94,194.27 204.1,194.27 190.59,180.77 182.28,180.77 179.2,177.69 167.84,177.69 v2(167.13,176.98) 167.13,176.54 170.62,173.05 170.62,147.89 171.18,147.33 171.18,143.94 170.26,143.02 170.26,140.3 169.34,139.38 169.34,136.79 170.43,135.69 170.43,134.89
  BOTTOM w0.127: v2(103.81,86.65) 104.09,86.65 104.22,86.78 104.22,89.8 106.17,91.76 106.17,96.8 103.71,99.26 103.71,155.3 108.94,160.53 108.94,187.61 110.79,189.46 110.79,198.18 112.9,200.29 112.9,211.79 113.95,212.84 121.55,212.84 126.25,208.14 126.25,196.19 128.08,194.36 149.99,194.36 167.13,177.22 v2(167.13,176.98) ; v2(33.03,90.95) 27.94,90.95 26.95,91.93 v2(21.13,91.93) ; J12.12 301.31,225.44 297.77,225.44 296.81,224.48 296.81,212.27 294.17,209.62 294.17,205.86 292.06,203.76 289.9,203.76 289.29,203.15 278.01,203.15 277.41,203.75 234.9,203.75 229.11,197.96 220.92,197.96 220.82,198.06 217.73,198.06 v2(217.04,197.37)
SOC_UART1_CTSN: length 95.7
  TOP w0.127: U1.U2 170.01,128.21 170.01,132.89 v1(169.21,133.69) ; U126.7 172.66,211.83 172.77,211.72 v2(172.77,211.09)
  L08_SIG2 w0.102: 169.21,134.89 v1(169.21,133.69)
  L08_SIG2 w0.127: 169.21,134.89 169.21,135.33 167.54,137 167.54,139.05 166.24,140.35 166.24,142.88 166.26,142.89 166.26,143.3 167.54,144.58 167.54,147.35 168.78,148.59 168.78,152.54 169.16,152.92 169.16,172.18 165.56,175.78 165.56,177.85 167.5,179.79 167.5,209.17 170.18,211.85 172.01,211.85 v2(172.77,211.09)
SOC_UART1_RTSN: length 96.5
  TOP w0.127: U126.5 171.36,210.48 v2(171.83,210.01) ; U1.U4 v1(170.81,126.61)
  L08_SIG2 w0.102: 169.6,134.81 169.6,133.06 169.85,132.81 169.85,128.16 169.6,127.9 169.6,127.14 169.72,127.01 170.33,127.01 170.54,126.81 170.61,126.81 v1(170.81,126.61)
  L08_SIG2 w0.127: 169.6,134.81 169.6,135.35 167.82,137.12 167.82,139.17 167.5,139.49 167.5,143.81 167.82,144.12 167.82,147.17 169.1,148.45 169.1,152.29 169.11,152.3 169.11,152.33 169.47,152.68 169.47,172.25 165.84,175.88 165.84,177.74 167.78,179.68 167.78,208.69 169.67,210.58 171.26,210.58 v2(171.83,210.01)
SOC_UART1_RXD: length 92
  TOP w0.127: v2(171.98,211.08) 171.98,213.47 U126.6 ; v1(170.81,127.41) U1.T3
  L08_SIG2 w0.102: v1(170.81,127.41) 170.81,128.21 170.33,128.69 170.33,133.09 170.15,133.26 170.15,134.89
  L08_SIG2 w0.127: 170.15,134.89 170.15,135.58 169.06,136.67 169.06,141.19 169.34,141.47 169.34,144.69 169.2,144.83 169.2,147.33 170.26,148.39 170.26,172.61 166.6,176.27 166.6,177.41 168.4,179.21 168.4,205.25 172.34,209.18 172.34,210.72 v2(171.98,211.08)
SOC_UART1_TXD: length 95.2
  TOP w0.127: U126.4 170.71,212.46 171.02,212.15 171.02,210.25 171.22,210.05 v2(171.22,209.46) ; U1.T5 v1(171.61,125.81)
  L08_SIG2 w0.102: 169.88,134.89 169.88,133.16 170.05,132.98 170.05,128.42 170.41,128.07 170.41,127.27 170.66,127.01 170.97,127.01 171.22,126.76 171.22,126.2 v1(171.61,125.81)
  L08_SIG2 w0.127: 169.88,134.89 169.88,135.46 168.78,136.55 168.78,141.3 169.06,141.58 169.06,144.53 169.1,144.57 169.1,144.59 168.96,144.73 168.96,147.43 169.34,147.82 169.34,152.19 170,152.85 170,172.28 166.24,176.04 166.24,177.75 168.06,179.56 168.06,208.21 169.29,209.44 170.75,209.44 170.78,209.46 v2(171.22,209.46)
SOC_UART2_DETECT: length 20.8
  TOP w0.127: U124.2 46.53,106.62 46.86,106.95 48.77,106.95 49.15,107.33 49.15,110.63 50.29,111.77 50.29,117.87 48.53,119.63 U68.4
SOC_UART2_RXD: length 185.8
  TOP w0.127: v2(44.73,117.72) 44.74,117.71 U76.5 ; U1.E21 v1(179.61,112.21) ; v2(44.7,104.54) 44.7,104.79 44.95,105.04 U124.9
  L03_SIG1 w0.102: 163.14,104.87 163.14,106.26 165.18,108.3 165.86,108.3 166.98,109.41 171.75,109.41 172.8,110.45 172.8,114.04 172.97,114.21 176.58,114.21 176.81,113.98 176.81,112.82 177.01,112.61 178.97,112.61 179.37,112.21 v1(179.61,112.21)
  L03_SIG1 w0.127: 163.14,104.87 161.34,103.06 153.85,103.06 150.98,100.19 150.98,87.87 148.74,85.64 133.12,85.64 130.63,88.13 113.33,88.13 110.46,88.13 109.32,89.27 91.01,89.27 90.31,88.57 63.47,88.57 47.75,104.28 44.96,104.28 v2(44.7,104.54) 44.7,106.54 48.01,109.84 48.01,111.52 47.12,112.41 47.12,114.06 44.7,116.47 44.7,117.69 v2(44.73,117.72)
