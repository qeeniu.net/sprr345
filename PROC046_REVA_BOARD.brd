# Allegro board PROC046_REVA_BOARD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_EHRPWM5B: length 200.9
  TOP w0.127: U1.E16 v1(179.61,116.21)
  L08_SIG2 w0.102: 189.1,114.07 187.59,114.07 187.2,113.68 182.8,113.68 182.29,114.19 181.07,114.19 180.83,114.44 180.83,114.99 v1(179.61,116.21)
  L08_SIG2 w0.127: v2(209.55,108.47) 209.55,108.66 208.68,109.53 208.68,109.55 208.41,109.82 206.4,109.82 202.95,113.27 197.03,113.27 196.23,114.07 189.1,114.07
  BOTTOM w0.127: J12.36 301.36,194.91 299.5,194.91 298.07,193.49 298.07,188.48 286.56,176.98 286.56,147.74 269.07,130.25 246.77,130.25 240.55,136.48 221.89,136.48 220.12,134.7 220.12,119.59 218.19,117.66 218.19,112.28 214.69,108.79 209.86,108.79 v2(209.55,108.47)
SOC_EHRPWM_TRIPZONE_INPUT3: length 219.1
  TOP w0.127: U1.H24 178.01,109.81 v1(178.01,108.14)
  L03_SIG1 w0.127: v2(230.12,131.97) 230.66,132.5 252.78,132.5 254.77,130.51 273.89,130.51 278.02,134.63 279.15,134.63 280.29,133.49 v2(281.81,133.49) ; v2(184.75,99.2) 185.34,99.79 187.11,99.79 187.36,99.54 187.36,97.42 188.4,96.37 190.46,96.37 192.2,94.63 193.8,94.63 195.31,93.12 207.52,93.12 209.43,95.04 212.18,95.04 221.48,104.33 228,104.33 230.04,106.37 230.04,109.35 v2(232.49,111.8)
  L08_SIG2 w0.127: v2(281.81,133.49) 285.75,137.43 285.75,178.83 298.17,191.25 J12.37
  BOTTOM w0.102: 180.97,104.03 180.57,104.43 179.2,104.43 178.98,104.65 178.98,107.8 178.64,108.14 v1(178.01,108.14)
  BOTTOM w0.127: v2(232.49,111.8) 232.49,112.56 230.76,114.29 230.76,130.82 230.12,131.46 v2(230.12,131.97) ; v2(184.75,99.2) 184.76,99.2 184.76,99.15 184.81,99.2 184.47,99.54 184.47,100.15 183.25,101.37 183.25,101.75 180.97,104.03
SOC_EHRPWM_TRIPZONE_INPUT4: length 181.3
  TOP w0.127: U1.E13 v1(179.61,118.61)
  L08_SIG2 w0.102: v1(179.61,118.61) 180,118.23 182.6,118.23 183.01,118.63 189.05,118.63 189.1,118.58
  L08_SIG2 w0.127: 189.1,118.58 189.43,118.58 189.7,118.85 190.51,118.85 192.81,116.55 194.67,116.55 197.96,119.84 200.37,119.84 200.61,119.6 202.84,119.6 203.75,120.5 221.91,120.5 222,120.41 v2(223.01,120.41)
  BOTTOM w0.127: v2(223.01,120.41) 223.01,133.01 222.82,133.2 222.82,134.19 223.09,134.46 238.81,134.46 245.25,128.02 270,128.02 288.8,146.82 288.8,171.97 294.13,177.31 300.4,177.31 301.24,178.15 301.24,179.84 J12.46
SOC_EHRPWM_TRIPZONE_INPUT5: length 190.5
  TOP w0.127: U1.F16 v1(178.81,116.21)
  L08_SIG2 w0.102: 189.1,116.16 188.5,115.56 183.51,115.56 182.45,116.63 179.22,116.63 v1(178.81,116.21)
  L08_SIG2 w0.127: v2(219.63,117.06) 217.68,119.01 203.94,119.01 201.71,116.78 201.56,116.78 201.56,116.78 201.18,116.78 201.1,116.85 198.82,116.85 198.74,116.78 197.68,116.78 196.41,115.51 196.4,115.51 196.3,115.41 191.07,115.41 190.18,116.3 189.24,116.3 189.1,116.16
  BOTTOM w0.127: J12.38 301.24,190 301.24,188.31 300.27,187.34 299.63,187.34 287.4,175.11 287.4,147.4 269.42,129.42 245.99,129.42 239.65,135.75 222.36,135.75 221.06,134.45 221.06,118.48 v2(219.63,117.06)
SOC_EMU00: length 46.7
  TOP w0.127: J19.19 v2(220.68,83.07)
  L08_SIG2 w0.127: v2(220.68,83.07) 221.16,83.07 221.31,83.23 221.31,83.83 221.18,83.96 220.12,83.96 219.99,84.09 219.99,84.75 219.86,84.88 219.61,84.88 219.48,84.75 219.48,84.09 219.35,83.96 219.1,83.96 218.71,84.36 218.71,85.43 217.37,86.77 217.37,88.4 215.8,89.97 214.84,89.97 213.69,91.12 213.69,92.7 213.87,92.88 213.87,97.37 211.88,99.35 210.24,99.35 209.73,99.86 206.16,99.86 205.82,100.21 205.82,100.78 205.51,101.08 204.56,101.08 204.39,100.92 v2(204.39,100.93)
  BOTTOM w0.127: R351.2 204.6,99.51 204.39,99.72 v2(204.39,100.93) 205.21,101.74 206.98,101.74 207.21,101.97 R350.2 ; v2(220.68,83.07) 220.7,83.05 220.7,80.25 221.67,79.28 U37.4
SOC_EMU01: length 44.6
  TOP w0.127: J19.21 v2(220.18,82.31)
  L08_SIG2 w0.127: v2(220.18,82.31) 220.64,81.85 221.37,81.85 221.64,82.12 221.64,83.91 220.09,85.46 219.23,85.46 217.68,87.01 217.68,88.43 215.86,90.25 214.9,90.25 213.93,91.22 213.93,92.51 214.25,92.83 214.25,97.33 211.26,100.32 v2(206.35,100.32)
  BOTTOM w0.127: v2(220.18,82.31) 220.34,82.15 220.34,76.55 220.57,76.32 221.13,76.32 221.46,76.65 221.46,77.21 221.59,77.33 U37.7 ; R355.2 206.35,99.19 v2(206.35,100.32) 206.45,100.22 206.88,100.22 207.31,99.79 R352.2
SOC_GPIO0_102: length 226.2
  TOP w0.127: v1(72.64,196.74) 72.15,197.23 U20.H4 ; U1.P4 v1(173.21,126.61)
  L03_SIG1 w0.102: 172.8,134.89 172.8,134.2 171.96,133.36 171.96,131.02 172.8,130.18 172.8,127.29 173.21,126.88 v1(173.21,126.61)
  L03_SIG1 w0.127: v2(170.61,194.05) 172.24,194.05 173.48,192.8 173.48,183.5 170.38,180.4 170.38,170.06 171.46,168.98 171.46,148.27 172.19,147.55 172.19,142.13 171.63,141.57 171.63,138.01 172.8,136.84 172.8,134.89 ; v2(165.99,208.8) 134.8,208.8 122.1,221.5 80.95,221.5 75.62,216.17 75.62,216.14 75.29,215.81 67.54,215.81 v2(65.53,217.82)
  BOTTOM w0.102: 69.6,197.25 72.14,197.25 v1(72.64,196.74)
  BOTTOM w0.127: 69.6,197.25 69.34,197.25 65.22,201.37 65.22,217.51 v2(65.53,217.82) ; v2(170.61,194.05) 165.99,198.67 v2(165.99,208.8)
SOC_GPMC_AD0: length 68.9
  TOP w0.127: U1.AC21 v1(165.21,112.21)
  L08_SIG2 w0.102: v1(165.21,112.21) 165.02,112.03 165.02,112.03 164.98,112 164.97,112 164.62,111.66 164.62,111.64 164.31,111.33 164.19,111.21 164.19,111.2 163.73,110.73 163.73,110.49 163.69,110.45 163.69,108.86 162.43,107.61 161.21,107.61
  L08_SIG2 w0.127: v2(115.7,124.22) 117.61,122.3 121.36,122.3 123.27,120.4 123.27,115.28 125.35,113.2 125.35,112.75 131.01,107.09 139.56,107.09 140.46,106.19 149.99,106.19 150.5,105.68 154.99,105.68 155.26,105.95 156.38,105.95 158.15,107.72 160.95,107.72 161.06,107.61 161.21,107.61
  BOTTOM w0.127: v2(115.7,124.22) 115.7,126.27 115.25,126.71 U87.29
SOC_GPMC_AD1: length 61.7
  TOP w0.127: v1(161.47,113.01) 161.99,113.53 162.32,113.53 162.56,113.29 163.89,113.29 U1.AE20
  L08_SIG2 w0.127: v2(115.94,126.76) 123.12,126.76 125.78,124.1 126.97,122.9 126.97,116.36 132.8,110.53 146.02,110.53 146.65,111.15 148.09,111.15 148.51,110.73 154.09,110.73 154.39,111.04 154.4,111.04 154.45,111.09 155.3,111.09 157.22,113.01 v1(161.47,113.01)
  BOTTOM w0.127: U87.30 115.75,126.95 v2(115.94,126.76)
SOC_GPMC_AD2: length 66.4
  TOP w0.127: v1(162.74,111.41) 164.41,111.41 U1.AD22
  L08_SIG2 w0.102: v1(162.74,111.41) 162.45,111.13 162.45,109.74 161.57,108.85 161.21,108.85
  L08_SIG2 w0.127: 161.21,108.85 155.45,108.85 154.86,108.27 149.05,108.27 148.15,107.37 140.91,107.37 140.07,108.21 131.47,108.21 126.49,113.18 126.49,113.68 124.69,115.48 124.69,122.03 123.71,123 119.56,123 117.98,124.58 117.08,124.58 v2(116.71,124.22)
  BOTTOM w0.127: v2(116.71,124.22) 116.21,124.73 116.21,126.18 116.46,126.43 116.46,127.01 116.25,127.22 U87.31
SOC_GPMC_AD3: length 62.2
  TOP w0.127: U1.AD20 164.41,113.01 v1(162.05,113.01)
  L08_SIG2 w0.102: 161.21,112.56 161.6,112.56 v1(162.05,113.01)
  L08_SIG2 w0.127: 161.21,112.56 158.52,112.56 157.86,111.9 157.12,111.9 156.03,110.81 154.57,110.81 154.52,110.76 154.51,110.76 154.2,110.45 148.39,110.45 147.97,110.87 146.77,110.87 146.15,110.25 132.69,110.25 126.7,116.24 126.7,122.79 126.64,122.84 123.51,125.97 123.05,125.97 118.08,125.97 118.08,125.97 v2(116.73,125.97)
  BOTTOM w0.127: U87.32 116.75,125.99 v2(116.73,125.97)
SOC_GPMC_AD4: length 58.2
  TOP w0.127: v1(159.64,110.89) 159.64,111.52 160.73,112.61 U1.AE21
  L08_SIG2 w0.127: v2(121.54,124.92) 121.86,124.6 123.69,124.6 125.32,122.98 125.86,122.44 125.86,115.9 132.38,109.37 146.52,109.37 147.18,110.04 147.57,110.04 147.98,109.62 154.58,109.62 154.94,109.97 158.98,109.97 159.64,110.63 v1(159.64,110.89)
  BOTTOM w0.127: U87.41 121.25,125.21 v2(121.54,124.92)
SOC_GPMC_AD5: length 58.2
  TOP w0.127: v1(161.47,111.41) 161.87,111.81 U1.AE22
  L08_SIG2 w0.102: v1(161.47,111.41) 161.21,111.41
  L08_SIG2 w0.127: 161.21,111.41 160.42,111.41 160.15,111.14 160.15,110.63 159.21,109.69 155.07,109.69 154.61,109.23 148.78,109.23 148.53,108.98 140.43,108.98 140.4,109.01 132.3,109.01 125.58,115.73 125.58,122.32 125.53,122.37 123.58,124.32 122.62,124.32 v2(122.12,123.83)
  BOTTOM w0.127: U87.42 121.75,126.13 122.12,125.75 v2(122.12,123.83)
SOC_GPMC_AD6: length 62.2
  TOP w0.127: U1.AC20 v1(165.21,113.01)
  L08_SIG2 w0.102: v1(165.21,113.01) 164.99,112.8 164.97,112.8 164.62,112.46 164.62,112.44 163.68,111.5 163.4,111.5 163.1,111.2 163.08,111.2 163.05,111.17 163.04,111.17 162.9,111.03 162.88,111.03 162.75,110.9 162.75,110.87 162.74,110.86 162.74,110.37 162.75,110.36 162.75,109.72 161.6,108.57 161.21,108.57
  L08_SIG2 w0.127: v2(123.16,122.51) 123.81,122.51 124.41,121.91 124.41,115.36 126.21,113.55 126.21,113.07 131.35,107.93 139.94,107.93 140.78,107.09 152.58,107.09 153.45,107.97 156.85,107.97 157.45,108.57 161.21,108.57
  BOTTOM w0.127: v2(123.16,122.51) 122.64,123.03 122.64,125.73 122.25,126.13 U87.43
SOC_GPMC_AD7: length 59.2
  TOP w0.127: v1(160.66,110.63) 160.66,111.77 161.09,112.21 164.41,112.21 U1.AD21
  L08_SIG2 w0.127: v2(123.16,123.83) 123.68,123.83 125.08,122.42 125.3,122.21 125.3,115.66 132.2,108.77 140.3,108.77 140.34,108.73 140.36,108.73 141.16,107.93 147.88,107.93 148.81,108.85 154.64,108.85 155.19,109.41 159.59,109.41 160.41,110.24 160.41,110.39 v1(160.66,110.63)
  BOTTOM w0.127: v2(123.16,123.83) 123.16,125.84 122.75,126.25 U87.44
SOC_GPMC_AD8: length 65.2
  TOP w0.127: U1.AE23 162.94,111.01 162.54,110.61 161.5,110.61 v1(161.48,110.63)
  L08_SIG2 w0.102: 161.21,110.35 161.21,110.36 161.47,110.61 161.47,110.63 v1(161.48,110.63)
  L08_SIG2 w0.127: 161.21,110.35 159.99,109.13 155.32,109.13 154.74,108.55 148.92,108.55 148.02,107.65 141.03,107.65 140.33,108.35 140.32,108.35 140.18,108.49 132.08,108.49 124.97,115.6 124.97,122.14 123.83,123.28 119.68,123.28 118.1,124.86 114.89,124.86 v2(114.22,125.54)
  BOTTOM w0.127: U87.26 113.75,126 v2(114.22,125.54)
SOC_GPMC_AD9: length 67.1
  TOP w0.127: U1.AB20 v1(166.01,113.01)
  L08_SIG2 w0.102: 163.19,112.66 162.92,112.66 162.23,111.98 161.22,111.98 161.21,111.98 ; v1(166.01,113.01) 165.62,113.4 164.59,113.4
  L08_SIG2 w0.127: v2(115.03,125.46) 115.3,125.19 118.83,125.19 119.05,125.41 123.28,125.41 125.43,123.26 126.14,122.56 126.14,116.01 132.53,109.62 146.33,109.62 147.03,110.31 147.71,110.31 148.13,109.9 154.46,109.9 154.81,110.25 156.59,110.25 157.48,111.14 158.11,111.14 158.95,111.98 161.21,111.98 ; 164.59,113.4 163.85,112.66 163.19,112.66
  BOTTOM w0.127: v2(115.03,125.46) 114.25,126.24 U87.27
SOC_GPMC_AD10: length 69.1
  TOP w0.127: U1.AA20 v1(167.61,113.01)
  L08_SIG2 w0.102: v1(167.61,113.01) 167.2,113.43 167.2,113.97 166.97,114.2 164.97,114.2 ; 161.34,112.26 161.99,112.26 162.71,112.98 163.07,112.98
  L08_SIG2 w0.127: 163.07,112.98 163.51,112.98 164.03,113.5 164.03,113.64 164.02,113.65 164.02,113.98 164.25,114.21 164.57,114.21 164.58,114.2 164.97,114.2 ; 161.34,112.26 158.72,112.26 157.99,111.52 157.25,111.52 156.26,110.53 154.69,110.53 154.33,110.17 148.26,110.17 147.84,110.59 146.9,110.59 146.24,109.93 132.61,109.93 126.42,116.13 126.42,122.67 126.37,122.72 123.39,125.69 123.16,125.69 118.52,125.69 118.29,125.47 115.75,125.47 v2(115.02,126.2)
  BOTTOM w0.127: U87.28 114.75,126.48 v2(115.02,126.2)
SOC_GPMC_AD11: length 64.8
  TOP w0.127: U1.AD23 164.41,110.61 v1(163.32,110.61)
  L08_SIG2 w0.102: 161.21,107.94 162.46,107.94 163.32,108.8 v1(163.32,110.61)
  L08_SIG2 w0.127: v2(117.6,124.09) 118.98,122.71 121.35,122.71 123.65,120.41 123.65,115.31 125.63,113.33 125.63,112.86 131.12,107.37 139.69,107.37 140.53,106.53 153.22,106.53 153.35,106.67 156.42,106.67 157.77,108.02 161.14,108.02 161.21,107.94
  BOTTOM w0.127: v2(117.6,124.09) 117.6,124.09 117.25,124.45 U87.33
SOC_GPMC_AD12: length 70.2
  TOP w0.127: U1.AA21 v1(167.61,112.21)
  L08_SIG2 w0.102: 164.36,110.97 164.36,111.08 164.4,111.11 164.4,111.12 164.83,111.55 164.83,111.57 165.05,111.8 165.07,111.8 165.1,111.83 167.22,111.83 v1(167.61,112.21)
  L08_SIG2 w0.127: 164.36,110.97 164.36,110.81 163.9,110.36 163.9,108.22 162.61,106.93 162.61,106.91 162.59,106.88 162.59,106.87 162.56,106.84 162.56,105.24 160.65,103.33 158.23,103.33 156.97,104.59 150.83,104.59 149.5,105.91 139.03,105.91 138.13,106.81 130.89,106.81 125.07,112.63 125.07,113.07 122.89,115.25 122.89,120.08 v2(121.29,121.68)
  BOTTOM w0.127: v2(121.29,121.68) 120.75,122.22 U87.40
SOC_GPMC_AD13: length 63.2
  TOP w0.127: U1.AB21 v1(166.01,112.21)
  L08_SIG2 w0.102: v1(166.01,112.21) 165.64,112.58 165.38,112.58 165.37,112.59 165.05,112.59 164.83,112.37 164.83,112.35 163.47,111 163.16,111 162.94,110.77 162.94,110.46 162.95,110.44 162.95,108.79 162.39,108.22 162.07,108.22 162.06,108.23 161.28,108.23 161.21,108.3
  L08_SIG2 w0.127: 161.21,108.3 157.66,108.3 156.31,106.95 153.21,106.95 153.07,106.81 140.65,106.81 139.81,107.65 131.24,107.65 125.93,112.95 125.93,113.42 124.03,115.32 124.03,121.59 v2(123.69,121.93)
  BOTTOM w0.127: v2(123.69,121.93) 123.69,126.01 123.25,126.45 U87.45
SOC_GPMC_AD14: length 68.1
  TOP w0.127: U1.AB22 v1(166.01,111.41)
  L08_SIG2 w0.102: v1(166.01,111.41) 165.62,111.02
  L08_SIG2 w0.127: v2(124.21,112.79) 124.21,112.54 124.31,112.44 124.47,112.44 131.56,105.35 148.47,105.35 150.17,103.65 157.1,103.65 157.98,102.77 160.88,102.77 163.07,104.96 163.07,106.74 164.36,108.03 164.36,110.17 164.82,110.62 164.82,110.78 165.05,111.01 165.06,111.01 165.08,111.02 165.62,111.02
  BOTTOM w0.127: v2(124.21,112.79) 124.21,126.13 123.75,126.58 U87.46
SOC_GPMC_AD15: length 70.1
  TOP w0.127: U1.AA22 v1(166.81,111.41)
  L08_SIG2 w0.102: v1(166.81,111.41) 166.4,111 166.4,110.38 166.21,110.2 165.38,110.2
  L08_SIG2 w0.127: 165.38,110.2 165.37,110.21 165.05,110.21 164.82,109.98 164.82,107.79 163.58,106.55 163.58,104.67 161.11,102.21 157.44,102.21 156.62,103.03 148.31,103.03 146.56,104.79 131.11,104.79 125.33,110.57 125.16,110.57 v2(124.84,110.89)
  BOTTOM w0.127: v2(124.84,110.89) 124.84,126.13 124.25,126.72 U87.47
SOC_GPMC_ALE: length 61.8
  TOP w0.127: U1.AC23 v1(165.21,110.61)
  L08_SIG2 w0.127: v2(117.86,112.16) 124.36,112.16 131.44,105.07 148.29,105.07 149.99,103.37 156.97,103.37 157.85,102.49 161,102.49 163.32,104.81 163.32,106.62 164.54,107.84 164.54,107.84 164.59,107.89 164.59,110.07 164.95,110.44 164.99,110.44 165.16,110.61 v1(165.21,110.61)
  BOTTOM w0.127: v2(117.86,112.16) 117.86,111.14 116.75,110.03 U87.17
SOC_GPMC_CLE: length 59
  TOP w0.127: U1.AC24 v1(165.21,109.81)
  L08_SIG2 w0.127: v2(117.25,107.35) 117.25,107.9 117.75,108.4 125.9,108.4 128.19,106.11 128.78,106.11 130.38,104.51 139.76,104.51 141.38,102.9 147.61,102.9 147.93,102.58 156.41,102.58 157.35,101.64 161.21,101.64 163.83,104.26 163.83,106.48 165.21,107.86 v1(165.21,109.81)
  BOTTOM w0.127: U87.16 v2(117.25,107.35)
SOC_GPMC_CSN0: length 57.4
  TOP w0.127: v1(166.81,105.6) 166.41,106 U1.AB25
  L08_SIG2 w0.102: 165.23,104.03 v1(166.81,105.6)
  L08_SIG2 w0.127: 165.23,104.03 161.98,100.78 156.09,100.78 154.57,99.25 151.71,99.25 150.84,100.12 142.86,100.12 141.92,101.06 141.91,101.06 141.17,101.79 129.54,101.79 125.81,105.53 122.07,105.53 v2(121.16,106.44)
  BOTTOM w0.127: v2(121.16,106.44) 120.75,106.85 U87.9
SOC_GPMC_RE#: length 59.7
  TOP w0.127: U1.AC22 v1(165.21,111.41)
  L08_SIG2 w0.102: 165.16,111.41 165.01,111.26
  L08_SIG2 w0.127: v2(121.79,113.55) 124.14,113.55 124.79,112.91 124.79,112.51 131.68,105.63 149.28,105.63 150.6,104.31 156.85,104.31 158.11,103.05 160.76,103.05 162.81,105.1 162.81,106.79 162.84,106.82 162.84,106.83 164.13,108.12 164.13,110.26 164.59,110.72 164.59,110.87 164.99,111.27 165.01,111.26 ; v1(165.21,111.41) 165.16,111.41
  BOTTOM w0.127: U87.8 121.25,113.01 v2(121.79,113.55)
SOC_GPMC_WAIT0: length 59.1
  TOP w0.127: v1(168.41,108.14) 168.41,109.81 U1.Y24 ; v2(121.92,107.33) 122.36,107.33 122.38,107.34 122.6,107.34 122.81,107.55 R761.2
  L08_SIG2 w0.102: 164.59,105.55 166.5,107.46 167,107.46 167.69,108.14 v1(168.41,108.14)
  L08_SIG2 w0.127: 164.59,105.55 164.59,104.13 161.52,101.06 155.98,101.06 155.5,100.57 149.92,100.57 149.64,100.85 148.84,100.85 148.34,101.36 142.01,101.36 141.3,102.07 129.82,102.07 128.47,103.42 128.47,104.33 126.62,106.19 123.06,106.19 v2(121.92,107.33)
  BOTTOM w0.127: v2(121.92,107.33) 121.75,107.5 U87.7
SOC_GPMC_WE#: length 65.1
  TOP w0.127: U1.Y22 v1(167.61,111.41)
  L08_SIG2 w0.102: 164.08,106.19 167.22,109.32 167.22,111.03 v1(167.61,111.41)
  L08_SIG2 w0.127: v2(116.46,107.33) 116.97,106.82 117.48,106.82 117.75,107.1 117.75,107.85 118.02,108.12 125.65,108.12 127.94,105.83 128.63,105.83 128.91,105.55 128.91,103.49 130.05,102.35 141.43,102.35 142.14,101.64 147.8,101.64 148.42,102.26 155.94,102.26 156.84,101.36 161.43,101.36 164.08,104.01 164.08,106.19
  BOTTOM w0.127: v2(116.46,107.33) 116.25,107.54 U87.18
SOC_GPMC_WP#: length 67.3
  TOP w0.127: v1(166.81,103.52) 168.27,103.52 168.71,103.95 168.71,105.09 168.84,105.23 168.84,109.38 U1.W25 ; R760.2 115.82,107.46 v2(115.44,107.08)
  L08_SIG2 w0.127: v1(166.81,103.52) 165.27,103.52 162.24,100.5 156.21,100.5 154.69,98.97 150.95,98.97 150.1,99.82 142.76,99.82 141.81,100.78 141.78,100.78 141.1,101.46 129.29,101.46 125.76,104.99 117.53,104.99 v2(115.44,107.08)
  BOTTOM w0.127: v2(115.44,107.08) 115.75,107.38 U87.19
SOC_I2C0_SCL: length 385.4
  TOP w0.127: R366.1 165.99,151.28 v2(165.73,151.54) ; R800.2 v2(204.09,236.36) ; U16.2 v2(78.3,215.43)
  L03_SIG1 w0.127: v2(204.09,236.36) 204.09,235.7 210.59,229.2 210.59,213.22 209.89,212.52 209.89,206.86 210.59,206.16 210.59,197.32 203.2,189.93 203.2,179.54 194.63,170.97 v2(194.18,170.97)
  L08_SIG2 w0.127: v2(165.73,151.54) 165.62,151.54 163.35,153.81 163.35,183.49 154.6,192.24 154.36,192.24 106.88,192.24 106.43,191.78 94.74,191.78 94.17,192.36 94.17,198.07 90.04,202.2 90.04,207.89 82.5,215.43 v2(78.3,215.43) ; v2(204.09,236.36) 204.09,235.92 207.2,232.81 218.44,232.81 222,236.36 226.39,236.36 228.55,234.2 254.38,234.2 257.56,231.03 273.3,231.03 299.16,205.18 301.26,205.18 J12.28
  BOTTOM w0.127: v2(194.18,170.97) 194.6,170.97 194.86,170.72 R700.2 194.96,170.21 195.63,169.53 198.17,169.53 199.54,168.16 199.54,164.94 198.09,163.49 174.22,163.49 170.1,159.37 170.1,155.91 v2(165.73,151.54) 165.99,151.28 R366.1
SOC_I2C0_SDA: length 388.7
  TOP w0.127: U16.3 v2(77.65,216.21) ; R801.2 v2(204.09,234.84) ; R265.2 v2(193.73,171.74) ; R365.1 v2(164.47,151.36)
  L03_SIG1 w0.127: v2(204.09,234.84) 210.26,228.67 210.26,213.48 209.65,212.87 209.65,206.47 210.26,205.86 210.26,197.6 202.92,190.26 202.92,179.93 194.72,171.74 v2(193.73,171.74)
  L08_SIG2 w0.127: v2(204.09,234.84) 206.63,232.3 218.57,232.3 221.23,234.96 224.03,234.96 224.66,234.33 227.46,234.33 229.36,232.42 253.75,232.42 255.78,230.39 271.4,230.39 299.13,202.66 301.23,202.66 J12.30 ; v2(77.65,216.21) 77.65,215.1 78.11,214.64 81.48,214.64 89.54,206.59 89.54,199.74 91.54,197.73 91.54,191.56 92.37,190.73 94.31,190.73 94.98,191.41 106.56,191.41 107.11,191.96 154.48,191.96 162.99,183.45 162.99,155.91 163.09,155.81 163.09,152.73 v2(164.47,151.36)
  BOTTOM w0.127: R365.1 v2(164.47,151.36) 165.39,152.29 169.75,156.65 169.75,159.76 173.84,163.84 197.99,163.84 199.26,165.11 199.26,167.91 197.99,169.18 194.46,169.18 193.5,170.14 193.5,171.51 v2(193.73,171.74)
SOC_I2C1_SCL: length 679.3
  TOP w0.127: U51.19 93.73,113.58 94.07,113.92 v2(95.26,113.92) ; v2(68.2,53.1) 68.2,53.55 68.03,53.72 J21.3 ; U96.1 271.57,42.39 271.4,42.56 271.4,43.65 267.49,47.56 v2(267.49,48.43) ; U112.1 157.28,145.25 157.16,145.13 157.16,144.4 v2(157.61,143.96) 157.92,143.64 157.92,143.46 160.27,141.11 162.56,141.11 162.94,141.49 162.94,144.85 163.16,145.06 R377.2 v2(163.7,145.98) ; R553.2 v2(292.99,44.85) ; v2(203.35,101.83) 199.81,101.83 198.88,100.9 R803.1 ; v2(96.92,29.5) U102.1
  L03_SIG1 w0.127: v2(212.24,112.84) 211.75,113.34 210.72,113.34 206.42,109.04 206.42,104.9 v2(203.35,101.83)
  L08_SIG2 w0.127: v2(68.2,53.1) 68.03,53.27 68.03,58.26 73.53,63.77 85.34,63.77 89.38,59.73 89.38,35.81 95.74,29.46 96.87,29.46 v2(96.92,29.5) ; v2(267.49,48.43) 267.06,48.43 266.43,47.81 266.43,46.84 255.5,35.91 255.5,34.46 251.66,30.62 250.6,30.62 249.58,29.61 241.3,29.61 240.98,29.29 238.85,29.29 238.43,28.87 236.29,28.87 234.65,30.51 234.65,32.07 231.41,35.31 228.71,35.31 226.44,37.58 226.44,39.59 225.73,40.3 225.73,50.07 224.84,50.96 224.84,64.06 226.12,65.34 226.12,68.55 224.49,70.19 224.49,78.38 226.59,80.49 226.59,86.16 225.82,86.93 225.82,87.66 225.25,88.23 224.36,88.23 223.85,88.74 222.98,88.74 222.71,88.47 222.61,88.47 222.6,88.46 221.9,88.46 221.89,88.47 219.31,88.47 219.3,88.46 218.6,88.46 218.59,88.47 218.49,88.47 217.79,89.16 217.79,89.17 216.16,90.8 215.44,90.8 215.24,90.99 215.24,92.46 214.76,92.94 214.76,97.5 211.13,101.13 209.52,101.13 208.83,101.83 v2(203.35,101.83)
  BOTTOM w0.127: v2(157.61,143.96) 157.14,144.43 157.14,147.29 157.4,147.55 161.12,147.55 161.8,148.22 161.8,149.67 167.79,155.66 167.79,177.21 150.29,194.71 128.22,194.71 126.64,196.28 126.64,208.14 121.64,213.15 113.82,213.15 112.62,211.95 112.62,211.9 112.62,200.67 110.49,198.54 110.49,189.75 108.15,187.42 107.11,187.42 101.52,187.42 100.28,186.17 100.28,127.52 95.24,122.48 95.24,114.39 95.26,114.37 v2(95.26,113.92) 95.26,105.45 92.69,102.87 92.69,65.32 94.21,63.79 94.21,61.43 90.47,57.69 77.76,57.69 72.71,52.64 68.66,52.64 v2(68.2,53.1) ; v2(212.24,112.84) 212.24,113.22 212.75,113.73 212.75,115.34 212.42,115.67 212.42,125.14 211.53,126.02 211.53,138.32 206.88,142.97 195.96,142.97 194.27,144.66 194.27,144.66 191.29,147.64 175.31,147.64 172.91,145.24 164.65,145.24 163.92,145.98 v2(163.7,145.98) R377.2 ; v2(267.49,48.43) 269.24,48.43 272.9,52.08 283.92,52.08 291.16,44.85 v2(292.99,44.85)
SOC_I2C1_SDA: length 669.9
  TOP w0.127: U51.20 93.23,113.92 93.51,114.2 94.32,114.2 v2(94.64,114.52) ; U112.6 157.28,147.4 v2(157.58,147.11) ; v2(202.41,101.11) 201.02,101.11 200.48,100.57 R804.1 ; R376.2 v2(162.18,145.98) ; v2(267,47.46) 270.81,43.65 270.81,42.13 271.05,41.89 U96.2 ; U102.2 97.42,29.24 v2(96.92,28.74) ; J21.4 69.03,53.61 69.09,53.55 v2(69.09,53.1) ; R558.2 v2(294.51,44.85)
  L03_SIG1 w0.127: v2(202.41,101.11) 202.67,101.36 203.53,101.36 206.76,104.59 206.76,108.98 210.83,113.06 211.29,113.06 211.96,112.38 212.43,112.38 212.9,112.86 v2(212.9,113.17)
  L08_SIG2 w0.127: v2(202.41,101.11) 202.56,101.26 203.45,101.26 203.75,101.55 208.6,101.55 209.3,100.85 211.07,100.85 214.5,97.42 214.5,92.72 214.17,92.39 214.17,91.32 214.93,90.56 216.06,90.56 217.55,89.07 217.55,89.06 218.39,88.23 218.44,88.23 218.45,88.22 219.4,88.22 219.41,88.23 221.79,88.23 221.8,88.22 222.69,88.22 223.18,87.74 225.09,87.74 225.54,87.29 225.54,86.82 226.35,86 226.35,80.6 223.57,77.82 223.57,70.73 225.88,68.42 225.88,66.33 224.42,64.87 224.42,39.21 228.6,35.03 231.3,35.03 234.37,31.96 234.37,30.78 234.37,30.45 236.52,28.3 240.33,28.3 241.4,29.36 249.68,29.36 250.68,30.37 251.87,30.37 255.78,34.28 255.78,35.68 259.18,39.08 259.18,39.13 267,46.95 v2(267,47.46) ; v2(69.09,53.1) 69.06,53.1 69.03,53.13 69.03,58.63 73.6,63.2 85.28,63.2 88.93,59.55 88.93,35.55 95.38,29.1 96.56,29.1 v2(96.92,28.74)
  BOTTOM w0.127: v2(69.09,53.1) 72.77,53.1 77.73,58.05 90.44,58.05 93.93,61.55 93.93,63.57 92.41,65.09 92.41,103.47 94.64,105.7 v2(94.64,114.52) 94.64,114.96 94.79,115.12 94.79,122.43 100,127.64 100,186.29 101.41,187.7 108.05,187.7 110.24,189.88 110.24,198.82 112.34,200.93 112.34,212.18 113.59,213.43 121.52,213.43 121.76,213.43 126.92,208.26 126.92,196.4 128.31,195.01 150.38,195.01 151.1,194.29 168.07,177.32 168.07,155.6 162.18,149.71 v2(162.18,145.98) ; v2(162.18,145.98) 162.64,146.44 163.97,146.44 164.88,145.52 172.81,145.52 175.21,147.92 191.41,147.92 196.09,143.25 207.14,143.25 211.81,138.57 211.81,126.15 212.7,125.26 212.7,115.79 213.08,115.41 213.08,113.35 v2(212.9,113.17) ; v2(162.18,145.98) R376.2 ; v2(162.18,145.98) 161.05,147.11 v2(157.58,147.11) ; v2(267,47.46) 268.67,47.46 272.66,51.45 283.84,51.45 290.91,44.39 294.06,44.39 v2(294.51,44.85)
SOC_I2C2_SCL: length 116
  TOP w0.127: R369.2 v2(169.8,150.78) 166.25,154.32 R814.2 ; R324.1 v2(256.16,161.56)
  L08_SIG2 w0.127: v2(256.16,161.56) 255.28,162.44 249.16,162.44 246.88,160.15 246.88,158.17 246.33,157.62 238.71,157.62 238.2,157.11 238.2,155.92 236.98,154.7 232.77,154.7 231.93,155.54 228.02,155.54 v2(227.84,155.72)
  BOTTOM w0.127: v2(227.84,155.72) 227.4,156.16 225.38,156.16 218.71,162.83 174.7,162.83 170.79,158.92 170.79,153.99 169.8,153 v2(169.8,150.78) R707.1
SOC_I2C2_SDA: length 116.7
  TOP w0.127: R815.2 166,152.8 v2(168.02,150.78) R368.2 ; R325.1 v2(257.94,161.56)
  L08_SIG2 w0.127: v2(227.71,156.86) 231.39,156.86 233.27,154.98 236.87,154.98 237.92,156.04 237.92,157.23 238.59,157.9 246.26,157.9 246.63,158.27 246.63,160.3 249.05,162.71 256.78,162.71 v2(257.94,161.56)
  BOTTOM w0.127: v2(227.71,156.86) 225.07,156.86 218.78,163.16 174.45,163.16 170.51,159.22 170.51,154.65 168.02,152.16 v2(168.02,150.78) R708.1
SOC_I2C_EN: length 44.2
  TOP w0.127: U16.5 v2(77,208.27) ; v1(78.38,191.14) 78.41,191.16 78.41,192.21 U20.V17
  L08_SIG2 w0.127: v2(77,208.27) 77.5,208.76 85.46,208.76 88.47,205.75 88.47,200.04 90.35,198.16 90.47,198.16 91.07,197.56 91.07,193.32 v2(90.17,192.42)
  BOTTOM w0.127: v2(90.17,192.42) 90.68,191.91 90.68,191.28 90.18,190.78 82.04,190.78 82.03,190.77 81.66,191.14 v1(78.38,191.14)
SOC_INT: length 204.7
  TOP w0.127: U30.10 81.25,172.38 81.79,171.85 81.79,165.11 82.63,164.27 93.95,164.27 109.31,179.63 109.31,187.94 110.24,188.86 110.24,198.9 108.84,200.29 108.84,204.74 108.84,204.74 108.84,205.15 109.51,205.81 116.81,213.11 122.13,213.11 136.98,198.26 146.27,198.26 162.43,182.1 162.43,178.88 170.74,170.58 172.59,170.58 v2(173.35,169.81) ; U1.N3 v1(174.01,126.61)
  L03_SIG1 w0.102: 174.29,134.89 174.29,134.25 174.47,134.08 174.47,129.76 173.6,128.88 173.6,127.03 v1(174.01,126.61)
  L03_SIG1 w0.127: 174.29,134.89 174.29,137 172.89,138.41 172.89,140.73 174.08,141.92 174.08,141.92 174.37,142.21 174.37,165.24 173.35,166.26 v2(173.35,169.81)
SOC_LED0: length 315.6
  TOP w0.127: R819.2 64.92,129.01 65.41,128.52 65.51,128.52 66.36,127.68 v2(67.31,127.68)
  L03_SIG1 w0.127: v2(219.46,136.79) 219.46,137.25 218.55,138.15 207.63,138.15 207.14,137.66 v2(200.74,137.66)
  L08_SIG2 w0.127: v2(192.63,184.75) 193.79,185.9 193.79,190.01 190.87,192.93 185.17,192.93 184.02,194.07 184.02,199.46 182.93,200.55 181.61,200.55 181.58,200.52 180.21,200.52 175.64,205.09 175.64,205.12 173.61,207.15 173.61,211.47 172.67,212.41 158.06,212.41 157.4,211.75 127.79,211.75 126.67,212.87 117.42,212.87 113.62,209.07 113.62,199.99 106.17,192.55 95.78,192.55 v2(94.67,193.66)
  BOTTOM w0.127: R428.1 201.56,136.83 v2(200.74,137.66) ; v2(67.31,127.68) 67.31,129.28 71.81,133.77 71.81,143.96 94.87,167.02 94.87,176.44 94.24,177.08 94.24,181.75 94.72,182.23 94.72,183.78 94.13,184.37 94.13,186.26 94.54,186.67 94.54,192.09 94.18,192.44 94.18,193.18 v2(94.67,193.66) ; v2(219.46,136.79) 219.46,138.19 229.19,147.93 229.19,156.83 228.18,157.85 225.25,157.85 223.8,159.29 223.8,163.27 212.2,174.87 206.58,174.87 205.36,176.09 205.36,181.42 202.03,184.75 v2(192.63,184.75)
SOC_LED1: length 326.5
  TOP w0.127: R818.2 v2(68.86,128.01) ; R462.1 200.02,114.06 200.32,113.77 204.25,113.77 204.6,114.11 208.41,114.11 208.74,113.78 209.63,113.78 214.55,118.71 214.55,122.93 218.57,126.94 v2(218.57,137.05)
  L08_SIG2 w0.127: v2(191.95,184.75) 191.95,185.19 193.51,186.76 193.51,189.63 190.59,192.55 185.04,192.55 183.77,193.82 183.77,199.28 182.81,200.24 180.12,200.24 173.27,207.09 173.27,211.29 172.43,212.13 158.22,212.13 157.56,211.47 127.64,211.47 126.52,212.59 117.54,212.59 113.9,208.95 113.9,199.89 106.17,192.17 95.3,192.17 v2(94.64,192.83)
  BOTTOM w0.127: v2(94.64,192.83) 94.64,192.38 94.82,192.2 94.82,186.55 94.41,186.15 94.41,184.48 95,183.9 95,182.08 94.52,181.6 94.52,177.23 95.15,176.6 95.15,166.87 72.72,144.44 72.72,131.03 69.7,128.01 v2(68.86,128.01) ; v2(191.95,184.75) 191.95,183.91 204.46,171.4 215.28,171.4 223.47,163.2 223.47,159.14 225.09,157.52 227.7,157.52 228.92,156.3 228.92,148.16 218.57,137.81 v2(218.57,137.05)
SOC_LED2: length 37.2
  TOP w0.127: LD4.1 73.69,136.39 74.44,135.64 74.44,120.78 84.64,110.57 U51.5
SOC_LED3: length 34.5
  TOP w0.127: LD2.1 77.5,119.37 85.79,111.07 U51.4
SOC_LED4: length 32
  TOP w0.127: LD5.1 80.8,117.59 86.81,111.57 U51.3
SOC_LRESETNMIENZ: length 139.1
  TOP w0.127: v1(169.21,132.42) 169.61,132.02 U1.V1 ; U24.20 v2(89.17,185.38)
  L08_SIG2 w0.102: v1(169.21,132.42) 168.54,133.09 168.54,134.89
  L08_SIG2 w0.127: 168.54,134.89 168.54,135.03 166.6,136.97 166.55,136.97 166.26,137.26 166.26,139.18 164.22,141.21 164.22,146.15 163.87,146.51 162.73,146.51 162.2,147.03 162.2,147.82 162.53,148.15 162.53,150.1 162.42,150.22 162.42,152.69 162.61,152.88 162.61,155.61 162.23,155.99 162.23,183.23 154.06,191.4 107.57,191.4 103.17,187.01 89.84,187.01 89.66,186.83 89.66,185.88 v2(89.17,185.38)
SOC_LRESETZ: length 141
  TOP w0.127: U1.V2 169.21,128.21 v1(169.21,129.88) ; v2(89.17,186.27) 88.67,185.77 U24.21
  L08_SIG2 w0.102: v1(169.21,129.88) 169.21,130.62 169.6,131 169.6,132.68 168.82,133.45 168.82,134.89
  L08_SIG2 w0.127: v2(89.17,186.27) 89.17,186.96 89.5,187.29 102.95,187.29 107.34,191.68 154.18,191.68 162.53,183.32 162.53,156.02 162.85,155.71 162.85,152.78 162.74,152.67 162.74,150.26 163.02,149.98 163.02,148.81 162.78,148.57 162.78,148.05 162.69,147.96 162.69,147.21 163.07,146.83 163.95,146.83 164.5,146.27 164.5,142.5 165.86,141.14 165.86,140.22 167.26,138.83 167.26,136.87 168.82,135.31 168.82,134.89
SOC_MCASP0ACLKR: length 141.6
  L03_SIG1 w0.127: JP1.59 288.29,81.71 288.29,88.89 286.05,91.12 286.05,91.42 286.07,91.44 286.07,102.29 276.78,111.57 257.32,111.57 247.35,121.54 216.22,121.54 215.11,122.65 209.32,122.65 208.91,122.24 203.13,122.24 202.42,122.95 201.07,122.95 201.02,122.9 198.54,122.9 196.89,124.55 195.23,124.55 195.21,124.53 v2(194.97,124.53)
  BOTTOM w0.127: R470.1 192.9,123.97 193.39,123.48 194.06,123.48 194.36,123.78 194.36,123.92 v2(194.97,124.53)
SOC_MCASP0ACLKX: length 174.4
  TOP w0.127: v2(297.54,53.69) 297.22,53.69 296.73,54.19 U115.4 ; v2(193.45,117.08) 193.52,117.01 193.07,117.01 192.86,116.8 192.86,116.29 R452.1
  L03_SIG1 w0.127: JP1.81 298.77,42.08 298.01,42.85 298.01,45.82 294.89,48.93 294.89,51.65 294.89,51.65 294.89,51.97 294.89,51.97 294.89,52.44 294.03,53.3 294.03,54.19 294.89,55.06 294.89,55.97 293.89,56.98 293.89,59.01 289.63,63.26 286.26,63.26 278.41,71.11 278.41,74.19 276.81,75.79 276.81,76.09 276.81,92.15 274.51,94.45 265.77,94.45 255.55,104.66 254.79,104.66 243.76,115.7 204.09,115.7 202.45,114.06 198.97,114.06 196.38,116.65 193.88,116.65 v2(193.45,117.08)
  BOTTOM w0.127: JP1.81 297.94,44.12 297.94,53.29 v2(297.54,53.69)
SOC_MCASP0AHCLKR: length 141.7
  TOP w0.127: R473.1 v2(193.98,125.49)
  L03_SIG1 w0.127: JP1.54 301.24,76.37 299.11,76.37 290.09,85.38 290.09,93.43 289.81,93.71 289.81,96.33 290.31,96.83 290.31,100.44 288.52,102.23 288.52,103.44 278.87,113.1 258.22,113.1 247.68,123.64 217.2,123.64 216.78,124.05 205.87,124.05 205.7,124.22 202.48,124.22 202.26,124.45 199.1,124.45 197.4,126.15 195.53,126.15 195.23,126.45 194.56,126.45 193.98,125.87 v2(193.98,125.49)
SOC_MCASP0AHCLKX: length 167.3
  TOP w0.127: v2(201.88,120.46) 201.88,120.91 202.16,121.19 v2(202.16,121.96) ; v2(296.88,62.68) 296.55,63.01 U139.2
  L03_SIG1 w0.127: v2(296.88,62.68) 294.89,64.66 294.89,68.44 282.17,81.16 282.17,94.76 282.5,95.09 282.5,96.98 282.28,97.21 280.85,98.63 280.85,104.42 275.81,109.45 256.24,109.45 247.35,118.34 222.59,118.34 222.32,118.61 221.67,119.27 215.39,119.27 214.2,120.46 v2(201.88,120.46)
  L08_SIG2 w0.127: v2(202.16,121.96) 202.08,122.04 202.08,127.12 201.71,127.49 201.04,127.49 200.03,126.48 198.78,126.48 196.55,128.72 196.55,129.58 195.25,130.88 v2(195.25,130.84)
  BOTTOM w0.127: v2(195.25,130.84) 194.42,130.01 192.85,130.01 R408.1 ; v2(201.88,120.46) 200.99,121.35 195.76,121.35 195.4,121.71 194.77,121.71 194.44,121.38 193.76,121.38 193.31,120.92 R458.1
SOC_MCASP0AMUTE: length 115.5
  L03_SIG1 w0.127: JP1.30 301.45,107.06 297.2,107.06 285.57,118.68 260.86,118.68 250.52,129.02 223.24,129.02 223.23,129.03 223.19,129.03 221.57,130.66 201.64,130.66 200.96,131.33 v2(199.77,131.33)
  BOTTOM w0.127: R444.1 197.98,131.33 198.47,131.82 199.28,131.82 v2(199.77,131.33)
SOC_MCASP0AXR0: length 157.2
  TOP w0.127: v2(297.54,54.69) 297.04,55.19 U115.6 ; R482.1 v2(199.01,125.24)
  L03_SIG1 w0.127: JP1.53 290.47,87.14 290.47,93.59 290.19,93.87 290.19,96.08 290.69,96.57 290.69,100.6 288.9,102.39 288.9,103.6 279.02,113.48 258.38,113.48 247.84,124.02 217.58,124.02 217.16,124.43 206.03,124.43 205.83,124.63 202.62,124.63 202.28,124.97 200.15,124.97 200.01,124.83 199.42,124.83 v2(199.01,125.24)
  L08_SIG2 w0.127: JP1.53 298.32,75.99 298.32,55.48 v2(297.54,54.69)
SOC_MCASP0AXR1: length 155.9
  TOP w0.127: R454.1 v2(193.95,122.44) ; U115.8 297.04,56.19 v2(297.54,55.69)
  L03_SIG1 w0.127: v2(193.95,122.44) 194.01,122.39 196.9,122.39 198.17,121.12 199.95,121.12 201.63,119.45 214.66,119.45 215.21,118.89 221.41,118.89 222.34,117.96 247.11,117.96 256.06,109.01 275.49,109.01 280.47,104.03 280.47,98.48 282.12,96.83 282.12,95.26 281.69,94.83 281.69,81.11 294.39,68.41 294.39,62.91 JP1.69
  BOTTOM w0.127: v2(297.54,55.69) 298.4,56.56 298.4,56.83 298.89,57.32 JP1.69
SOC_MCASP0AXR2: length 156.3
  TOP w0.127: v2(296.65,56.69) 296.17,56.69 296.17,56.69 U115.9 ; v2(198.98,123.43) 198.7,123.71 R451.1
  L03_SIG1 w0.127: JP1.60 301.23,71.31 299.34,71.31 288.77,81.88 288.77,88.99 286.45,91.32 286.45,102.69 277.11,112.03 257.58,112.03 246.99,122.62 215.77,122.62 215.37,123.03 209.01,123.03 208.63,122.65 203.26,122.65 202.58,123.33 200.08,123.33 200,123.26 199.16,123.26 v2(198.98,123.43)
  BOTTOM w0.127: JP1.60 301.24,68.75 298.96,68.75 297.94,67.73 297.94,60.47 296.65,59.17 v2(296.65,56.69)
SOC_MCASP0AXR3: length 154.9
  TOP w0.127: v2(297.54,56.69) 297.04,57.19 U115.10 ; R447.1 v2(193.95,120.92)
  L03_SIG1 w0.127: JP1.76 301.05,51.17 299.01,51.17 298.15,52.03 298.15,56.53 297.98,56.69 v2(297.54,56.69) 297.54,58.16 293.24,62.46 293.24,67.71 278.36,82.59 278.36,92.83 276.25,94.93 276.25,95.48 273.5,98.24 270.21,98.24 260.38,108.07 255.8,108.07 246.71,117.16 221.81,117.16 221.04,117.92 214.12,117.92 213.33,118.71 200.62,118.71 199.43,119.9 198.73,119.9 196.96,121.67 194.7,121.67 v2(193.95,120.92)
SOC_MCASP0AXR4: length 134.2
  L03_SIG1 w0.127: JP1.57 289.23,83.31 289.23,89.09 286.69,91.63 286.69,104.12 278.51,112.31 257.86,112.31 247.27,122.9 216.39,122.9 215.89,123.41 202.87,123.41 202.69,123.59 200.34,123.59 200.22,123.71 v2(199.77,123.71)
  BOTTOM w0.127: v2(199.77,123.71) 199.46,124.03 198.84,124.03 198.53,123.71 R480.1
SOC_MCASP0AXR5: length 124.4
  L03_SIG1 w0.127: JP1.45 296.93,90.85 296.93,93.61 292.57,97.97 292.57,103.83 281.03,115.37 259.59,115.37 249.08,125.87 221.82,125.87 220.69,127 204.97,127 204.71,126.75 202.06,126.75 201.87,126.56 201.31,126.56 200.84,127.02 v2(199.84,127.02)
  BOTTOM w0.127: R476.1 197.98,126.76 198.47,126.27 199.28,126.27 199.84,126.83 199.84,127.01 v2(199.84,127.02)
SOC_MCASP0AXR6: length 147.1
  L03_SIG1 w0.127: v2(198.27,118.25) 198.27,117.82 198.72,117.38 199.79,117.38 200.34,116.83 208.84,116.83 209.07,116.6 246.39,116.6 255.49,107.51 259.28,107.51 269.19,97.6 273.34,97.6 275.69,95.25 275.69,94.66 277.77,92.57 277.77,81.9 292.48,67.2 292.48,62.54 295.83,59.18 295.83,50.24 298.91,47.16 JP1.77
  BOTTOM w0.127: v2(198.27,118.25) 198.27,118.2 197.91,118.57 R472.1
SOC_MCASP0AXR7: length 133.7
  L03_SIG1 w0.127: JP1.52 301.29,78.96 299.29,78.96 292.74,85.51 292.74,94.77 291.45,96.05 290.93,96.57 290.93,100.75 289.28,102.4 289.28,103.6 279.12,113.76 258.5,113.76 247.95,124.3 220.93,124.3 220.89,124.34 220.83,124.34 220.47,124.7 219.94,125.22 209.4,125.22 208.87,124.7 206.13,124.7 205.96,124.87 202.72,124.87 202.35,125.24 200.32,125.24 200.24,125.31 v2(199.8,125.31)
  BOTTOM w0.127: R469.1 198.36,125.24 198.82,125.69 199.31,125.69 199.38,125.63 199.48,125.63 v2(199.8,125.31)
SOC_MCASP0AXR8: length 147.8
  TOP w0.127: R441.1 v2(203.81,116.07)
  L03_SIG1 w0.127: v2(203.81,116.07) 203.83,116.09 204.2,116.09 204.22,116.08 245.1,116.08 254.63,106.54 257.99,106.54 269.7,94.83 274.66,94.83 277.19,92.31 277.19,76.14 287.27,66.05 289.94,66.05 291.64,64.35 291.64,61.79 295.27,58.16 295.27,49.09 298.5,45.86 298.5,44.19 299.34,43.35 301.25,43.35 JP1.82
SOC_MCASP0AXR9: length 150.9
  TOP w0.127: R437.1 v2(203.86,114.52)
  L03_SIG1 w0.127: JP1.83 298.42,39.54 297.62,40.34 297.62,45.65 294.41,48.86 294.41,51.88 293.55,52.75 293.55,54.24 293.17,54.62 293.17,56.15 292.35,56.96 292.35,60 289.48,62.88 282.57,62.88 278.02,67.43 278.02,74.03 276.38,75.68 276.38,91.84 275.08,93.13 274.28,93.13 274.02,93.4 274.02,93.69 273.63,94.07 265.61,94.07 255.4,104.28 254.63,104.28 243.6,115.32 208.26,115.32 207.46,114.52 v2(203.86,114.52)
SOC_MCASP0AXR10: length 22.1
  TOP w0.127: U1.E11 v1(179.61,120.21) ; v2(190.12,118.35) 190.27,118.2 R820.2 191.57,118.2 192.16,117.6 194.32,117.6 194.68,117.24 194.68,116.5 196.58,114.61 R462.2
  L03_SIG1 w0.102: 189.1,117.62 186.74,117.62 185.45,118.91 ; 181.61,119.14 181.61,119.67 181.46,119.83 180.87,119.83 180.49,120.21 v1(179.61,120.21)
  L03_SIG1 w0.127: v2(190.12,118.35) 189.38,117.62 189.1,117.62 ; 185.45,118.91 184.96,119.39 182.78,119.39 182.4,119.01 181.74,119.01 181.61,119.14
SOC_MCASP0AXR10_R: length 157
  TOP w0.127: v2(194.18,118.51) 193.84,118.16 192.84,118.16 R820.1
  L03_SIG1 w0.127: v2(194.18,118.51) 194.82,117.87 196.85,117.87 197.62,117.1 199.63,117.1 200.18,116.55 208.61,116.55 208.84,116.32 245.26,116.32 254.66,106.92 258.9,106.92 269.77,96.05 272.75,96.05 273.69,95.11 274.78,95.11 277.5,92.4 277.5,76.85 285.75,68.59 289.43,68.59 292.1,65.93 292.1,62.58 295.55,59.12 295.55,49.7 299.31,45.94 301.29,45.94 JP1.78
SOC_MCASP0AXR12: length 141.6
  L03_SIG1 w0.127: JP1.71 298.86,55.9 298.86,57.6 294,62.45 294,68.09 280.85,81.24 280.85,90.49 280.71,90.63 280.71,93.14 280.86,93.3 280.86,93.92 274.91,99.86 270.08,99.86 261.32,108.63 256.04,108.63 246.98,117.69 222.15,117.69 221.26,118.58 214.99,118.58 214.38,119.19 201.24,119.19 v2(199.77,120.66)
  BOTTOM w0.127: R459.1 197.98,120.66 198.47,120.17 199.28,120.17 v2(199.77,120.66)
SOC_MCASP0AXR13: length 139.7
  L03_SIG1 w0.127: v2(199.9,122.06) 200.34,122.06 200.9,121.5 203.47,121.5 203.62,121.35 215.37,121.35 216.43,120.28 221.98,120.28 223.06,119.2 248.07,119.2 256.7,110.58 276.77,110.58 285.39,101.96 285.39,101.8 285.4,101.79 285.4,93.02 285.39,93.01 285.39,91.79 284.76,91.15 284.76,80.16 JP1.63
  BOTTOM w0.127: R481.1 198.53,122.19 198.76,122.42 199.54,122.42 v2(199.9,122.06)
SOC_MCASP0AXR14: length 142.3
  TOP w0.127: R460.1 198.91,122.19 199.03,122.06 v2(199.03,121.91)
  L03_SIG1 w0.127: JP1.65 295.74,66.64 295.74,68.64 282.83,81.55 282.83,91.3 283.63,92.1 283.63,92.12 283.89,92.38 283.91,92.38 284.43,92.9 284.43,95.75 284.56,95.87 284.56,99.23 283.57,100.22 283.57,102.63 275.97,110.23 256.54,110.23 247.8,118.96 222.96,118.96 222.01,119.92 216.14,119.92 214.96,121.1 202.92,121.1 202.79,121.22 200.81,121.22 200.43,121.6 199.34,121.6 v2(199.03,121.91)
SOC_MCASP0AXR15: length 145.2
  TOP w0.127: R477.1 v2(199.01,120.66)
  L03_SIG1 w0.127: v2(199.01,120.66) 200.72,118.95 214.03,118.95 214.71,118.28 221.16,118.28 222,117.44 246.83,117.44 255.92,108.35 260.73,108.35 269.67,99.41 274.2,99.41 279.78,93.83 279.78,81.68 293.62,67.83 293.62,62.42 298.55,57.49 298.55,54.24 299.26,53.53 301.26,53.53 JP1.72
SOC_MCASP0FSR: length 148
  TOP w0.127: R468.1 v2(193.9,123.97)
  L03_SIG1 w0.127: v2(193.9,123.97) 195.19,123.97 195.39,124.17 196.43,124.17 198.08,122.52 200.36,122.52 200.43,122.44 202.39,122.44 202.97,121.86 209.07,121.86 209.47,122.27 214.93,122.27 216.6,120.6 222.01,120.6 223.16,119.45 248.56,119.45 257.18,110.82 276.9,110.82 285.69,102.03 285.69,91.59 285.01,90.92 285.01,80.94 299.79,66.16 301.3,66.16 JP1.64
SOC_MCASP0FSX: length 166.5
  TOP w0.127: U115.5 296.81,54.69 297.31,54.19 297.99,54.19 298.3,54.5 298.3,60.31 299.21,61.23 301.34,61.23 JP1.66
  L03_SIG1 w0.127: JP1.66 301.26,61.15 299.26,61.15 295.27,65.14 295.27,68.59 282.55,81.32 282.55,94.59 282.88,94.92 282.88,95.36 284.28,96.75 284.28,99.09 283.13,100.23 283.13,102.67 276.19,109.61 275.97,109.83 256.4,109.83 247.51,118.72 222.75,118.72 221.82,119.65 215.55,119.65 214.36,120.84 202.79,120.84 202.72,120.92 200.66,120.92 200.22,121.36 198.36,121.36 196.65,123.08 v2(194.84,123.08)
  BOTTOM w0.127: v2(194.84,123.08) 193.94,123.08 193.54,122.67 193.52,122.67 193.29,122.44 R448.1
SOC_MCASP1ACLKR: length 119.6
  TOP w0.127: v2(195.17,132.09) 194.73,132.09 194.61,132.21 193.87,132.21 193.56,131.9 193.56,131.89 193.26,131.59 R398.1
  L03_SIG1 w0.127: JP1.33 285.1,117.92 261.08,117.92 260.7,118.3 250.59,128.41 250.57,128.41 250.34,128.64 223.03,128.64 221.93,129.75 202.01,129.75 200.93,130.83 200.59,130.83 200.59,130.82 198.7,130.82 197.43,132.09 v2(195.17,132.09)
SOC_MCASP1ACLKX: length 123.2
  L03_SIG1 w0.127: v2(193.89,131.44) 194.04,131.59 194.16,131.59 194.16,131.59 197.4,131.59 198.57,130.42 200.8,130.42 201.86,129.36 221.77,129.36 222.87,128.26 250.18,128.26 250.41,128.03 250.43,128.03 260.92,117.54 284.78,117.54 298.22,104.09 298.22,103.11 299.48,101.85 301.32,101.85 JP1.34
  BOTTOM w0.127: R405.1 193.55,131.59 193.55,131.59 193.74,131.59 v2(193.89,131.44)
SOC_MCASP1AHCLKR: length 129.6
  L03_SIG1 w0.127: JP1.42 301.32,91.69 299.48,91.69 298.78,92.39 298.78,92.57 293.72,97.63 293.72,103.73 281.7,115.75 259.86,115.75 249.36,126.25 222.3,126.25 221.1,127.46 204.52,127.46 204.19,127.13 202.61,127.13 202.09,127.64 198.63,127.64 197.52,128.75 195.06,128.75 195,128.69 v2(193.98,128.69)
  BOTTOM w0.127: v2(193.98,128.69) 193.83,128.54 R402.1
SOC_MCASP1AMUTE: length 22
  TOP w0.127: U1.A5 183.39,125.41 184.66,126.68 186.85,126.68 187.41,127.25 187.41,127.67 188.09,128.35 189.44,128.35 190.25,129.16 190.96,129.16 R817.2 191.54,128.62 192.03,129.1 192.03,129.1 192.21,129.29 192.21,129.29 192.25,129.33 193.9,129.33 194.77,130.19 194.77,131.09 195.03,131.36 195.41,131.36 195.9,130.88 200.09,130.88 200.87,131.66 R823.2
SOC_MCASP1AMUTE_R: length 106.5
  TOP w0.127: R823.1 v2(203.5,131.66)
  L03_SIG1 w0.127: JP1.27 299.84,110.53 298.27,110.53 289.37,119.43 261.23,119.43 250.9,129.76 250.85,129.76 250.82,129.78 223.67,129.78 221.79,131.66 v2(203.5,131.66)
SOC_MCASP1AXR0: length 112.3
  TOP w0.127: v2(199.01,131.33) 198.58,131.76 R439.1
  L03_SIG1 w0.127: v2(199.01,131.33) 199.54,131.87 200.94,131.87 201.85,130.95 221.61,130.95 223.29,129.28 250.62,129.28 260.97,118.93 286.32,118.93 297.12,108.12 JP1.29
SOC_MCASP1AXR1: length 119.5
  TOP w0.127: R434.1 v2(199.01,129.81)
  L03_SIG1 w0.127: v2(199.01,129.81) 199.48,129.33 200,129.33 200.77,128.56 202.37,128.56 202.55,128.74 221.51,128.74 222.62,127.64 249.92,127.64 260.64,116.92 284.46,116.92 297.56,103.82 297.56,100.94 299.06,99.44 301.45,99.44 JP1.36
SOC_MCASP1AXR2: length 121.5
  TOP w0.127: R430.1 202.38,125.95 v2(203.2,125.95)
  L03_SIG1 w0.127: v2(203.2,125.95) 203.51,126.26 206.22,126.26 206.45,126.48 220.13,126.48 221.27,125.34 248.37,125.34 258.92,114.8 279.59,114.8 291.99,102.4 291.99,97.26 296.29,92.95 296.29,87.11 298.14,85.26 JP1.47
SOC_MCASP1AXR3: length 123.6
  TOP w0.127: v2(199.26,128.54) 198.82,128.54 198.56,128.28 R425.1
  L03_SIG1 w0.127: JP1.40 301.45,94.36 299.53,94.36 296.52,97.37 296.52,104.04 284.19,116.37 260.34,116.37 249.56,127.15 222.42,127.15 221.31,128.26 204.26,128.26 203.82,127.82 202.8,127.82 202.35,128.26 200.7,128.26 200.43,128.54 v2(199.26,128.54)
SOC_MCASP1AXR4: length 115.5
  TOP w0.127: R422.1 202.97,128.01 v2(203.24,128.28)
  L03_SIG1 w0.127: v2(203.24,128.28) 203.47,128.5 221.41,128.5 222.52,127.4 249.73,127.4 260.48,116.65 284.33,116.65 295.32,105.66 295.33,105.66 297.13,103.86 297.13,97.22 298.91,95.44 299.96,95.44 JP1.39
SOC_MCASP1AXR5: length 139.4
  TOP w0.127: R419.1 v2(203.81,117.59)
  L03_SIG1 w0.127: JP1.75 298.91,49.7 296.15,52.46 296.15,59.21 292.86,62.5 292.86,67.45 278.05,82.26 278.05,92.7 275.97,94.78 275.97,95.37 273.38,97.96 269.77,97.96 259.94,107.79 255.63,107.79 246.53,116.88 221.58,116.88 220.86,117.6 208.88,117.6 208.03,118.46 204.67,118.46 v2(203.81,117.59)
SOC_MCASP1AXR6: length 127.9
  TOP w0.127: R416.1 198.89,126.76 199.06,126.93 v2(199.06,127.03)
  L03_SIG1 w0.127: v2(199.06,127.03) 199.52,126.56 200.94,126.56 201.22,126.28 201.94,126.28 202.16,126.51 205.99,126.51 206.02,126.53 206.25,126.76 220.24,126.76 221.41,125.59 248.97,125.59 259.43,115.13 280.7,115.13 292.27,103.56 292.27,97.54 296.57,93.23 296.57,89.7 299.53,86.74 301.45,86.74 JP1.46
SOC_MCASP1AXR7: length 142.7
  L03_SIG1 w0.127: JP1.58 301.33,73.75 299.82,73.75 289.71,83.86 289.71,93.27 289.43,93.55 289.43,96.56 289.69,96.81 289.69,98.64 288.09,100.24 288.09,103.29 278.74,112.64 257.87,112.64 247.37,123.14 247.36,123.14 247.24,123.26 216.6,123.26 216.21,123.65 203.06,123.65 202.87,123.84 200.69,123.84 200.36,124.17 198.84,124.17 197.27,125.74 195.35,125.74 195.12,125.98 v2(194.89,125.98)
  BOTTOM w0.127: v2(194.89,125.98) 193.39,125.98 192.9,125.49 R414.1
SOC_MCASP1AXR8: length 116.4
  L03_SIG1 w0.127: v2(199.77,129.81) 200.86,129.81 201.69,128.98 221.61,128.98 222.72,127.88 250.03,127.88 250.26,127.65 250.28,127.65 260.77,117.16 284.62,117.16 297.84,103.94 297.84,101.06 298.39,100.5 JP1.35
  BOTTOM w0.127: R412.1 198.36,129.81 198.54,129.99 198.54,130 198.81,130.28 198.83,130.28 198.9,130.34 199.24,130.34 v2(199.77,129.81)
SOC_MCASP1AXR9: length 135.6
  TOP w0.127: R410.1 v2(193.93,127.01)
  L03_SIG1 w0.127: JP1.51 298.91,80.18 294.18,84.91 294.18,93.66 291.55,96.29 291.17,96.67 291.17,100.98 289.64,102.52 289.64,103.67 279.27,114.04 258.6,114.04 248.06,124.58 221.25,124.58 220.93,124.58 220.93,124.58 219.92,125.59 209.26,125.59 208.66,125 206.43,125 206.31,125.11 202.82,125.11 202.59,125.34 202.41,125.52 200.91,125.52 200.63,125.8 199.21,125.8 198.82,126.18 198.09,126.18 197.05,127.22 195.3,127.22 195.1,127.01 v2(193.93,127.01)
SOC_MCASP1FSR: length 127.4
  TOP w0.127: v2(194.01,130.47) 193.56,130.47 193.26,130.16 R394.1
  L03_SIG1 w0.127: JP1.41 296.11,96.75 296.11,104.02 284,116.13 260.21,116.13 249.71,126.63 222.5,126.63 221.3,127.84 204.36,127.84 204.03,127.51 202.77,127.51 202.25,128.02 198.79,128.02 196.47,130.34 194.13,130.34 v2(194.01,130.47)
SOC_MCASP1FSX: length 120.4
  L03_SIG1 w0.127: JP1.28 301.45,109.6 296.77,109.6 287.2,119.17 261.14,119.17 261.11,119.19 261.1,119.19 250.79,129.5 250.75,129.5 250.72,129.53 223.47,129.53 221.8,131.2 202.07,131.2 201.09,132.17 198.09,132.17 197.03,133.24 v2(195.2,133.24)
  BOTTOM w0.127: R404.1 192.9,133.11 193.54,133.75 194.69,133.75 v2(195.2,133.24)
SOC_MCASP2ACLKR: length 115.5
  TOP w0.127: v2(195.2,134.63) 194.71,135.13 193.39,135.13 192.9,134.63 R401.1
  L03_SIG1 w0.127: v2(195.2,134.63) 197.97,134.63 198.81,133.8 199.62,133.8 199.82,134 201.76,134 202.44,133.31 204.01,133.31 204.7,132.63 221.86,132.63 221.91,132.58 221.92,132.58 224.08,130.42 251.1,130.42 251.13,130.39 251.28,130.39 251.49,130.19 251.49,130.16 261.59,120.06 294.02,120.06 294.09,119.98 298.33,115.74 JP1.23
SOC_MCASP2ACLKX: length 31.8
  TOP w0.127: R413.1 193.48,133.11 193.61,133.24 v2(194.06,133.24) ; U64.13 198.53,154.05 v2(199.11,154.62)
  L08_SIG2 w0.127: v2(199.11,154.62) 199.56,154.62 199.68,154.5 199.68,153.26 195.06,148.64 195.06,145.91 192.41,143.25 192.41,143.24 192.33,143.16 192.33,138.27 194.11,136.49 194.11,135.75 194.54,135.32 194.54,133.72 v2(194.06,133.24)
  BOTTOM w0.127: U136.4 198.52,154.04 v2(199.11,154.62)
SOC_MCASP2AHCLKR: length 92.9
  TOP w0.127: U56.3 v2(197.36,95.52) ; v2(199.75,137.33) 199.59,137.17 198.4,137.17 R407.1
  L03_SIG1 w0.127: v2(199.75,137.33) 199.92,137.15 207.75,137.15 208.11,136.79 216.92,136.79 v2(216.97,136.74) ; v2(216.53,102.94) 212.47,98.87 212.47,98.09 212.47,97.77 211.36,96.66 208.13,96.66 206.92,95.46 205.03,95.46 204.96,95.52 v2(197.36,95.52)
  BOTTOM w0.127: v2(216.97,136.74) 218.34,135.37 218.34,120.72 216.2,118.59 216.2,113.62 212.23,109.65 208.7,109.65 207.44,108.4 207.44,104.36 208.53,103.27 210.24,103.27 210.57,102.94 v2(216.53,102.94)
SOC_MCASP2AHCLKX: length 135.9
  L03_SIG1 w0.127: JP1.48 301.29,84.04 298.12,84.04 295.83,86.32 295.83,92.55 291.71,96.67 291.6,96.78 291.6,102.24 279.43,114.42 258.76,114.42 248.22,124.96 221.09,124.96 219.95,126.1 206.6,126.1 205.99,125.49 202.97,125.49 202.97,125.5 202.56,125.9 202.56,125.9 201.06,125.9 200.78,126.18 199.37,126.18 198.98,126.57 198.24,126.57 197.21,127.6 195.14,127.6 195.04,127.5 v2(194.79,127.5)
  BOTTOM w0.127: R417.1 193.24,127.01 193.73,127.5 v2(194.79,127.5)
SOC_MCASP2AMUTE: length 23.5
  TOP w0.127: U1.C2 182.01,128.21 v1(182.01,129.88)
  BOTTOM w0.102: 189.1,131.38 188.57,130.85 186.36,130.85 186.05,131.16 183.28,131.16 v1(182.01,129.88)
  BOTTOM w0.127: 189.1,131.38 189.64,131.92 189.64,132.83 189.92,133.11 189.92,133.98 190.12,134.18 190.12,135.14 190.5,135.52 190.5,136.26 190.89,136.65 193.92,136.65 193.93,136.67 195.17,136.67 195.93,135.9 R822.2 R393.2
SOC_MCASP2AMUTE_R: length 109.6
  L03_SIG1 w0.127: JP1.21 298.26,118.28 295.86,120.69 262.08,120.69 251.73,131.04 251.4,131.04 251.38,131.05 224.46,131.05 221.27,134.24 204.81,134.24 203.61,135.45 202.56,135.45 201.88,136.13 199.24,136.13 v2(199.01,135.9)
  BOTTOM w0.127: R822.1 v2(199.01,135.9)
SOC_MCASP2AXR0: length 29.5
  TOP w0.127: U1.D3 v1(180.41,127.41)
  BOTTOM w0.102: 180.72,128.09 180.41,127.78 v1(180.41,127.41) ; 182.85,129.1 184.71,130.95 185.97,130.95 186.28,130.65 188.77,130.65 189.1,130.98
  BOTTOM w0.127: 182.85,129.1 181.41,129.1 180.72,128.41 180.72,128.09 ; 189.1,130.98 189.94,131.82 189.94,132.4 189.94,132.4 189.94,132.74 190.2,132.99 190.2,133.87 190.42,134.09 190.42,135.07 190.45,135.09 190.45,135.12 190.75,135.42 190.75,136.16 190.96,136.36 195,136.36 195.71,135.65 195.71,134.61 195.93,134.38 R821.2 196.58,134.93 196.91,135.25 199.39,135.25 200.26,136.13 R428.2
SOC_MCASP2AXR0_R: length 112.6
  L03_SIG1 w0.127: JP1.22 301.62,117.4 301.62,117.39 301.35,117.11 299.05,117.11 295.72,120.44 261.77,120.44 251.87,130.34 251.87,130.37 251.46,130.77 251.31,130.77 251.28,130.8 224.26,130.8 222.1,132.96 222.07,132.96 222.07,132.98 222.02,133.03 221.72,133.03 221.69,133.01 207.57,133.01 206.81,133.77 204.77,133.77 203.84,134.71 201.2,134.71 200.87,134.38 200.49,134.38 200.49,134.38 v2(199.01,134.38)
  BOTTOM w0.127: R821.1 v2(199.01,134.38)
SOC_MCASP2AXR1: length 29.3
  TOP w0.127: R423.1 198.17,134.38 199.59,135.8 202.13,135.8 202.82,136.49 209.3,136.49 210.46,137.66 210.46,150.36 209.62,151.21 U135.3
