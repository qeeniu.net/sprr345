# Allegro board PROC046_REVA_BOARD.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R752  1K  [RES0402]  178.99 48.15 0 bottom
R753  10K_1%  [RES0402]  176.33 63.51 90 bottom
R754  10K_1%  [RES0402]  174.8 63.51 90 bottom
R755  10K_1%  [RES0402]  274.83 47.39 270 bottom
R756  10K_1%  [RES0402]  273.3 47.39 270 bottom
R757  10K_1%  [RES0402]  173.28 63.51 90 bottom
R758  0E_1%  [RES0402]  91.87 38.41 90 bottom
R759  10K_1%  [RES0402]  171.75 63.51 90 bottom
R760  10K_1%  [RES0402]  115.82 109.11 270 top
R761  10K_1%  [RES0402]  122.81 109.11 270 top
R762  33E_1%  [RES0402_0-5]  275.59 42.94 180 bottom
R763  1K  [RES0402]  170.23 63.51 90 bottom
R764  10K_1%  [RES0402]  96.85 42.79 0 bottom
R765  4.3K_5%  [RES0402]  96.85 41.26 0 bottom
R766  4.7K_5%  [RES0402]  96.85 33.39 180 bottom
R767  10K_1%  [RES0402]  164.52 55.89 180 bottom
R768  1K  [RES0402]  168.71 63.51 90 bottom
R769  2.2K_1%  [RES0402]  101.17 47.36 270 bottom
R770  1.5K_5%  [RES0402]  165.28 58.18 0 bottom
R771  0E_1%  [RES0402]  105.49 41.65 0 bottom
R772  0E_1%  [RES0402]  89.44 28.95 270 bottom
R773  100E_0.1%  [RES0402]  132.03 18.91 180 bottom
R774  100E_0.1%  [RES0402]  138.13 18.79 180 bottom
R775  100E_0.1%  [RES0402]  135.08 16.75 180 bottom
R776  10K_1%  [RES0402]  234.87 31.97 180 bottom
R777  10K_1%  [RES0402]  242.62 31.59 0 bottom
R778  10K_1%  [RES0402]  234.87 30.44 180 bottom
R779  10K_1%  [RES0402]  242.62 30.06 0 bottom
R780  10K_1%  [RES0402]  234.87 28.92 180 bottom
R781  10E  [RES0402]  222.63 70.25 90 top
R782  4.7K_5%  [RES0402]  258.67 48.71 0 top
R783  10K_1%  [RES0402]  255.14 104.79 0 top
R784  10K_1%  [RES0402]  159.77 144.67 0 top
R785  10K_1%  [RES0402]  159.77 144.67 180 bottom
R786  4.7K_5%  [RES0402]  99.06 194.83 0 top
R787  100E_5%  [RES0402]  223.23 152.73 90 top
R788  0E_1%  [RES0402]  269.62 153.56 270 top
R789  0E_1%  [RES0402]  250.82 150.89 270 top
R790  0E_1%  [RES0402]  235.84 149.62 0 top
R791  0E_1%  [RES0402]  235.97 140.6 0 top
R792  0E_1%  [RES0402]  248.67 138.32 0 top
R793  10K_1%  [RES0402]  120.65 207.15 90 top
R796  10K_1%  [RES0402]  230.16 145.29 270 top
R800  0E_1%  [RES0402]  205.61 236.36 180 top
R801  0E_1%  [RES0402]  205.61 234.84 180 top
R802  10K_1%  [RES0402]  205.74 227.98 270 top
R803  0E_1%  [RES0402]  198.88 98.95 270 top
R804  0E_1%  [RES0402]  200.48 98.98 270 top
R806  0E_1%  [RES0402]  284.92 60.55 0 top
R807  0E_1%  [RES0402]  134.7 45.73 0 bottom
R808  1K  [RES0402]  134.19 53.98 180 top
R809  10K_1%  [RES0402]  134.7 45.73 0 top
R812  10K_1%  [RES0402]  201.13 144.17 0 top
R813  10K_1%  [RES0402]  294.87 50.87 0 top
R814  0E_1%  [RES0402]  162.69 154.32 0 top
R815  0E_1%  [RES0402]  162.69 152.8 0 top
R816  22E_1%  [RES0402]  201.63 130.09 0 top
R817  0E_1%  [RES0402]  192.15 128.62 180 top
R818  0E_1%  [RES0402]  68.86 129.63 270 top
R819  0E_1%  [RES0402]  64.92 129.76 270 top
R820  0E_1%  [RES0402]  192.15 118.2 180 top
R821  0E_1%  [RES0402]  197.23 134.38 180 bottom
R822  0E_1%  [RES0402]  197.23 135.9 180 bottom
R823  0E_1%  [RES0402]  201.63 131.66 180 top
R824  33K_1%  [RES0603]  242.14 241.14 90 top
R825  10K_1%  [RES0402]  241.5 243.75 0 top
R826  10K_1%  [RES0402]  234.14 237.45 180 top
R827  10K_1%  [RES0402]  294.23 56.2 180 bottom
R828  0E_1%  [RES0402]  106.43 87.52 90 bottom
R829  10K_1%  [RES0402]  177.42 229.76 90 top
R830  10K_1%  [RES0402]  167.21 218.12 90 top
R832  10K_1%  [RES0402]  126.9 101.54 180 top
R833  10K_1%  [RES0402]  134.04 105.5 0 top
R834  10K_1%  [RES0402]  47.99 114.99 180 top
R835  10K_1%  [RES0402]  46.23 103.52 270 bottom
R836  10K_1%  [RES0402]  48.01 106.06 180 top
R837  10K_1%  [RES0402]  33.17 212.18 0 top
R838  10K_1%  [RES0402]  167.21 215.05 270 top
R839  10K_1%  [RES0402]  170.08 210.35 90 top
R840  10K_1%  [RES0402]  182.52 208.68 90 top
R841  10K_1%  [RES0402]  179.83 213.32 270 top
R842  10K_1%  [RES0402]  179.73 217.69 270 top
R843  10K_1%  [RES0402]  194.56 210.12 270 top
R844  4.7K_5%  [RES0402]  70.38 218.2 270 top
R845  4.7K_5%  [RES0402]  64.49 218.18 270 top
R846  10K_1%  [RES0402]  29.74 209.26 0 top
R847  10K_1%  [RES0402]  40.79 207.74 90 top
R848  10K_1%  [RES0402]  43.46 205.96 90 top
R849  10K_1%  [RES0402]  19.18 91.84 90 top
R850  10K_1%  [RES0402]  20.96 89.17 0 top
R851  0E  [RES0402]  234.14 237.45 180 bottom
R852  10K_1%  [RES0402]  234.14 238.98 0 top
R853  0E  [RES0402]  237.57 241.65 270 top
R854  10K_1%  [RES0402]  130.61 35.19 180 top
R855  10K_1%  [RES0402]  221.49 246.6 180 top
R856  0E  [RES0402]  185.94 190.91 180 top
R857  0E  [RES0402]  154.05 96.66 0 top
R858  0E  [RES0402]  229.23 156.73 270 top
R859  10K_1%  [RES0402]  88.14 187.97 90 bottom
R860  10K_1%  [RES0402]  83.44 175.4 270 top
R861  10K_1%  [RES0402]  58.8 177.81 90 top
R862  10K_1%  [RES0402]  81.92 175.4 270 top
R863  10K_1%  [RES0402]  55.88 178.2 270 bottom
R864  0E_1%  [RES0402]  221.61 85.36 90 top
R865  10K_1%  [RES0402]  217.42 85.36 270 top
R866  22E_1%  [RES0402]  219.33 95.39 270 top
R867  10K_1%  [RES0402]  235.43 90.9 270 bottom
R868  10K_1%  [RES0402]  231.47 108.78 0 top
R869  10K_1%  [RES0402]  192.28 139.59 270 top
R870  10K_1%  [RES0402]  203.36 150.72 270 top
R871  10K_1%  [RES0402]  33.15 88.91 180 top
R872  10K_1%  [RES0402]  35.94 90.82 90 top
R873  10K_1%  [RES0402]  202.79 152.3 270 bottom
R874  10K_1%  [RES0402]  203.35 149.17 90 bottom
R875  0E_1%  [RES0402]  287.86 60.7 270 top
R876  33E  [RES0402]  297.66 51.81 90 top
R877  33E  [RES0402]  201.93 82.69 180 top
R878  10K_1%  [RES0402]  97.16 206.64 270 top
R879  1K  [RES0402]  218.82 70.25 90 top
R880  1.5K_5%  [RES0402]  250.19 47.26 270 bottom
R881  10K_1%  [RES0402]  108.08 190.51 270 top
R882  10K_1%  [RES0402]  106.3 190.51 270 top
R883  10K_1%  [RES0402]  102.36 193.18 180 top
R884  10K_1%  [RES0402]  102.36 194.83 180 top
R885  470E  [RES0402]  97.16 237.63 270 top
R886  10K_1%  [RES0402]  284.48 69.86 180 top
R887  10K_1%  [RES0402]  284.35 64.78 180 top
R888  10K_1%  [RES0402]  238.63 162.7 270 bottom
R889  10K_1%  [RES0402]  264.03 98.06 180 top
R890  0E_1%  [RES0402]  154.43 91.71 0 top
R891  0E_1%  [RES0402]  154.43 93.23 0 top
R892  0E  [RES0402]  283.72 211.98 90 bottom
R893  10K_1%  [RES0402]  281.03 200.78 0 top
R894  0E  [RES0402]  286.38 43.07 270 top
R895  0E  [RES0402]  149.45 99.46 180 bottom
R896  0E  [RES0402]  154.05 98.19 0 top
R897  0E  [RES0402]  284.25 203.77 90 top
R898  33K_1%  [RES0603]  289.03 202.94 90 top
R899  10K_1%  [RES0402]  288.39 205.55 0 top
R900  10K_1%  [RES0402]  281.69 198.24 270 top
R901  10K_1%  [RES0402]  280.16 198.21 90 top
R902  10K_1%  [RES0402]  216.94 208.47 90 top
R903  10K_1%  [RES0402]  205.87 208.13 180 top
R904  10K_1%  [RES0402]  228.73 87.01 180 bottom
R905  10K_1%  [RES0402]  220.85 103.27 0 bottom
R907  0E  [RES0402]  277.37 202.71 180 top
R908  0E  [RES0402]  277.37 204.36 180 top
R909  0E  [RES0402]  234.44 243.35 90 top
R910  10K_1%  [RES0402]  202.31 156.61 0 bottom
R911  10K_1%  [RES0402]  202.31 154.95 180 bottom
R912  10K_1%  [RES0402]  197.23 144.29 0 top
R913  10K_1%  [RES0402]  197.23 142.64 0 top
R914  4.87K_1%  [RES0402]  39.47 103.39 90 top
R915  10K_1%  [RES0402]  41.12 103.39 90 top
R917  5.62k_1%  [RES0603]  276.99 209.44 90 bottom
R918  261K_1%  [RES0402]  279.02 209.69 90 bottom
R919  237K_1%  [RES0402]  280.54 209.69 90 bottom
R920  47K _1%  [RES0402]  274.7 213.76 180 bottom
R921  47K _1%  [RES0402]  274.83 215.41 180 bottom
R922  100K  [RES0402]  277.5 213.37 90 top
R923  10K  [RES1206]  252.86 230.9 90 top
R924  10K  [RES0402]  252.86 226.33 180 top
R925  100K  [RES0402]  252.86 228.11 180 top
R926  10K  [RES1206]  258.44 241.44 0 top
R927  0E_1%  [RES0402]  177.55 139.21 90 bottom
RA1  22E  [RESA_0402-4]  232.13 76.77 90 top
RA2  22E  [RESA_0402-4]  247.5 74.74 270 top
RA3  22E  [RESA_0402-4]  232.13 73.6 90 top
RA4  22E  [RESA_0402-4]  247.5 71.95 270 top
RA5  22E  [RESA_0402-4]  245.47 63.06 0 top
RA6  0E  [RESA_0402-4]  184.78 140.22 0 top
RA7  0E  [RESA_0402-4]  178.56 100.73 180 top
RA8  0E  [RESA_0402-8]  172.9 93.51 0 bottom
RA9  0E  [RESA_0402-8]  168.07 93.51 0 bottom
RA10  0E  [RESA_0402-4]  177.16 98.31 0 bottom
RA11  22E  [RESA_0402-4]  244.07 60.14 180 bottom
RA12  22E  [RESA_0402-4]  246.86 60.14 180 bottom
RA13  22E  [RESA_0402-4]  241.27 60.14 180 bottom
RA14  22E  [RESA_0402-4]  251.18 58.99 90 bottom
RA15  0E  [RESA_0402-4]  184.78 140.22 180 bottom
RA16  1K  [RESA_0402-4]  144.02 117.11 180 bottom
RA17  10E  [RESA_0402-4]  180.72 100.73 0 bottom
RA18  10E  [RESA_0402-8]  173.05 98.52 180 bottom
RA19  10E  [RESA_0402-8]  167.92 98.54 180 bottom
SW1  500ASSP3M2QE  [SW3_100_400X200_TH]  266.7 245.46 0 top
SW2  B3SL-1022P  [SW4_EVQQ2_255X240_SMD]  123.76 244.49 270 top
SW3  1571983-4  [SW8_GDH04S04_265X245]  85.17 231.87 270 top
SW4  B3SL-1022P  [SW4_EVQQ2_255X240_SMD]  115.12 244.49 270 top
SW5  B3SL-1022P  [SW4_EVQQ2_255X240_SMD]  106.49 244.49 270 top
SW6  B3SL-1022P  [SW4_EVQQ2_255X240_SMD]  97.85 244.49 270 top
SW7  B3SL-1022P  [SW4_EVQQ2_255X240_SMD]  89.22 244.49 270 top
SW8  B3SL-1022P  [SW4_EVQQ2_255X240_SMD]  274.7 170.45 90 top
SW9  B3SL-1022P  [SW4_EVQQ2_255X240_SMD]  287.02 170.32 270 top
SW10  B3SL-1022P  [SW4_EVQQ2_255X240_SMD]  80.58 244.49 270 top
SW11  SDA01H1SBD  [SW2_100X324-80_180X300_SMD]  149.25 247.56 270 top
SW12  SDA01H1SBD  [SW2_100X324-80_180X300_SMD]  5.74 44.34 0 top
SW13  SDA01H1SBD  [SW2_100X324-80_180X300_SMD]  139.42 49.86 0 top
SW14  SDA01H1SBD  [SW2_100X324-80_180X300_SMD]  129.87 49.86 0 top
SW15  SDA01H1SBD  [SW2_100X324-80_180X300_SMD]  226.69 149.17 0 top
TP9  SMD  [TP40_SMD]  88.2 105.04 0 top
TP13  SMD  [TP40_SMD]  74.93 182.77 0 top
TP14  SMD  [TP40_SMD]  175.77 232.04 0 top
TP15  SMD  [TP40_SMD]  180.97 232.04 0 top
TP16  SMD  [TP40_SMD]  178.82 232.04 0 top
TP17  SMD  [TP40_SMD]  185.17 232.17 0 top
TP18  SMD  [TP40_SMD]  183.13 232.08 0 top
TP19  SMD  [TP40_SMD]  57.66 182.93 0 top
TP20  SMD  [TP40_SMD]  62.1 182.77 0 top
TP21  SMD  [TP40_SMD]  69.22 183.02 0 top
TP22  SMD  [TP40_SMD]  67.82 182.64 0 top
TP23  SMD  [TP40_SMD]  200.79 241.7 270 top
TP25  SMD  [TP40_SMD]  200.79 243.47 270 top
TP26  SMD  [TP40_SMD]  200.79 245.25 270 top
TP29  SMD  [TP40_SMD]  281.53 103.62 270 top
TP30  SMD  [TP40_SMD]  163.19 235.35 0 top
TP31  SMD  [TP40_SMD]  165.15 235.35 0 top
TP33  SMD  [TP40_SMD]  157.99 237.25 0 top
TP34  SMD  [TP40_SMD]  159.77 237.12 0 top
TP35  SMD  [TP40_SMD]  161.67 237.12 0 top
TP36  SMD  [TP40_SMD]  261.24 98.06 0 top
TP37  SMD  [TP40_SMD]  259.41 101.61 180 top
TP38  SMD  [TP40_SMD]  259.33 99.71 180 top
TP39  SMD  [TP40_SMD]  250.06 112.92 180 top
TP40  SMD  [TP40_SMD]  252.32 62.42 0 top
TP41  SMD  [TP40_SMD]  248.03 112.92 180 top
TP42  THRU HOLE  [TP_40X65]  251.08 223.41 90 top
TP43  SMD  [TP40_SMD]  225.27 59.07 0 top
TP44  SMD  [TP40_SMD]  245.87 112.92 180 top
TP45  SMD  [TP40_SMD]  225.27 60.85 0 top
TP46  SMD  [TP40_SMD]  243.71 112.79 180 top
TP47  SMD  [TP40_SMD]  225.27 57.29 0 top
TP48  SMD  [TP40_SMD]  265.81 56.2 0 top
TP49  SMD  [TP40_SMD]  225.27 55.51 0 top
TP50  SMD  [TP40_SMD]  265.79 54.17 0 top
TP51  THRU HOLE  [TP_40X65]  5.54 21.45 90 top
TP52  SMD  [TP40_SMD]  262 206.9 90 top
TP53  THRU HOLE  [TP_40X65]  11.58 225.59 90 top
TP54  SMD  [TP40_SMD]  74.17 206.39 0 top
TP55  SMD  [TP40_SMD]  234.77 240.63 90 top
TP56  SMD  [TP40_SMD]  63.88 202.96 0 top
TP57  SMD  [TP40_SMD]  251.31 38.27 0 top
TP58  SMD  [TP40_SMD]  57.53 195.85 0 top
TP59  SMD  [TP40_SMD]  59.69 195.98 0 top
TP61  THRU HOLE  [TP_40X65]  267.72 207.05 90 top
TP62  THRU HOLE  [TP_40X65]  242.3 216.22 90 top
TP63  THRU HOLE  [TP_40X65]  269.11 219.34 90 top
TP64  THRU HOLE  [TP_40X65]  293.07 162.07 90 top
TP65  SMD  [TP40_SMD]  249.53 38.22 0 top
TP66  SMD  [TP40_SMD]  64.52 206.9 0 top
TP67  SMD  [TP40_SMD]  62.61 206.9 0 top
TP68  SMD  [TP40_SMD]  64.14 193.44 0 top
TP69  SMD  [TP40_SMD]  60.83 201.44 0 top
TP70  SMD  [TP40_SMD]  59.05 201.44 0 top
TP71  SMD  [TP40_SMD]  61.21 199.53 0 top
TP72  SMD  [TP40_SMD]  57.66 191.91 0 top
TP73  SMD  [TP40_SMD]  57.53 193.82 0 top
TP74  SMD  [TP40_SMD]  55.5 195.98 0 top
TP75  SMD  [TP40_SMD]  55.5 197.75 0 top
TP76  SMD  [TP40_SMD]  57.55 197.75 0 top
TP77  SMD  [TP40_SMD]  59.82 197.88 0 top
TP78  SMD  [TP40_SMD]  62.61 205.25 0 top
TP79  SMD  [TP40_SMD]  60.71 205.12 0 top
TP80  SMD  [TP40_SMD]  60.71 203.34 0 top
TP81  SMD  [TP40_SMD]  63.12 199.53 0 top
TP82  SMD  [TP40_SMD]  247.73 38.17 0 top
TP84  THRU HOLE  [TP_40X65]  242.33 186.45 0 top
TP85  THRU HOLE  [TP_40X65]  236.35 185.94 0 top
TP86  SMD  [TP40_SMD]  78.11 185.05 0 top
TP88  THRU HOLE  [TP_40X65]  256.79 184.93 0 top
TP89  THRU HOLE  [TP_40X65]  260.35 184.93 0 top
TP90  THRU HOLE  [TP_40X65]  104.65 167.63 0 top
TP91  THRU HOLE  [TP_40X65]  265.68 184.16 0 top
TP92  THRU HOLE  [TP_40X65]  268.73 184.16 0 top
TP93  SMD  [TP40_SMD]  66.17 182.64 0 top
TP94  SMD  [TP40_SMD]  64.39 182.64 0 top
TP95  SMD  [TP40_SMD]  70.97 183.02 0 top
TP96  SMD  [TP40_SMD]  72.9 183.02 0 top
TP97  SMD  [TP40_SMD]  78.11 182.77 0 top
TP98  SMD  [TP40_SMD]  80.39 182.64 0 top
TP100  THRU HOLE  [TP_40X65]  265.56 181.62 0 top
TP101  THRU HOLE  [TP_40X65]  229.46 175.07 0 top
TP102  THRU HOLE  [TP_40X65]  263.02 178.96 0 top
TP103  THRU HOLE  [TP_40X65]  113.03 167.63 0 top
TP104  THRU HOLE  [TP_40X65]  88.44 101.34 0 top
TP106  SMD  [TP40_SMD]  145.75 175.58 0 top
TP107  THRU HOLE  [TP_40X65]  263.78 175.78 0 top
TP108  THRU HOLE  [TP_40X65]  267.84 169.69 0 top
TP109  THRU HOLE  [TP_40X65]  267.97 172.1 0 top
TP110  THRU HOLE  [TP_40X65]  229.11 170.19 0 top
TP111  THRU HOLE  [TP_40X65]  267.97 174.51 0 top
TP112  THRU HOLE  [TP_40X65]  230.48 153.86 0 top
TP113  THRU HOLE  [TP_40X80]  229.23 164.48 0 top
TP114  THRU HOLE  [TP_40X65]  265.46 163.11 0 top
TP115  SMD  [TP40_SMD]  145.62 160.34 0 top
TP116  THRU HOLE  [TP_40X65]  262.89 160.8 0 top
TP117  THRU HOLE  [TP_40X65]  263.96 169.33 0 top
TP118  THRU HOLE  [TP_40X65]  260.35 160.67 0 top
TP119  THRU HOLE  [TP_40X65]  228.6 159.65 0 top
TP120  THRU HOLE  [TP_40X65]  239.7 198.36 0 top
TP121  THRU HOLE  [TP_40X65]  245.36 156.48 0 top
TP122  THRU HOLE  [TP_40X65]  248.41 156.48 0 top
TP123  SMD  [TP40_SMD]  145.54 145.25 0 top
TP124  SMD  [TP40_SMD]  180.62 154.85 0 top
TP125  SMD  [TP40_SMD]  186.74 147.11 0 top
TP126  SMD  [TP40_SMD]  145.59 129.99 0 top
TP127  SMD  [TP40_SMD]  186.08 92.14 0 top
TP128  SMD  [TP40_SMD]  145.54 115.97 270 top
TP129  THRU HOLE  [TP_40X65]  266.29 84.11 0 top
TP131  SMD  [TP40_SMD]  175.97 150.36 0 top
TP132  SMD  [TP40_SMD]  189.81 97.65 0 top
TP133  SMD  [TP40_SMD]  154.3 142.51 0 top
TP135  SMD  [TP40_SMD]  176.4 148.5 0 top
TP136  SMD  [TP40_SMD]  154.3 136.79 0 top
TP138  SMD  [TP40_SMD]  157.75 97.46 180 bottom
TP139  SMD  [TP40_SMD]  154.3 138.7 0 top
TP140  SMD  [TP40_SMD]  154.3 140.6 0 top
TP141  SMD  [TP40_SMD]  180.31 153.2 0 top
TP142  SMD  [TP40_SMD]  188.59 147.08 0 top
TP143  SMD  [TP40_SMD]  181.05 151.58 0 top
TP144  SMD  [TP40_SMD]  158.39 102.12 180 bottom
TP145  SMD  [TP40_SMD]  195.96 100.85 0 top
TP146  SMD  [TP40_SMD]  153.62 98.87 180 bottom
TP147  SMD  [TP40_SMD]  157.76 99.94 180 bottom
TP149  SMD  [TP40_SMD]  159.38 99.96 180 bottom
TP150  SMD  [TP40_SMD]  153.67 97.3 180 bottom
TP151  SMD  [TP40_SMD]  156.21 97.3 180 bottom
TP152  SMD  [TP40_SMD]  46.86 71.39 0 top
TP153  SMD  [TP40_SMD]  153.16 118.89 0 top
TP154  SMD  [TP40_SMD]  155.19 114.19 0 top
TP155  SMD  [TP40_SMD]  151.26 118.89 0 top
TP157  SMD  [TP40_SMD]  175.82 101.39 180 bottom
TP158  SMD  [TP20_SMD]  138.56 95.65 0 top
TP159  SMD  [TP40_SMD]  191 100.31 0 top
TP160  SMD  [TP20_SMD]  139.95 84.72 0 top
TP161  SMD  [TP20_SMD]  139.95 83.71 0 top
TP162  SMD  [TP20_SMD]  139.95 82.69 0 top
TP163  SMD  [TP20_SMD]  139.95 81.68 0 top
TP164  SMD  [TP40_SMD]  271.14 47 0 top
TP165  SMD  [TP40_SMD]  271.27 44.97 0 top
TP166  SMD  [TP20_SMD]  98.76 48.63 90 top
TP167  SMD  [TP40_SMD]  282.45 41.29 0 top
TP168  SMD  [TP40_SMD]  284.35 41.29 0 top
TP169  SMD  [TP40_SMD]  270.94 34.15 0 top
TP170  SMD  [TP40_SMD]  272.75 34.15 0 top
TP171  SMD  [TP20_SMD]  162.36 53.35 270 top
TP172  SMD  [TP40_SMD]  276.22 28.08 0 top
TP173  SMD  [TP40_SMD]  278 28.08 0 top
TP174  SMD  [TP40_SMD]  134.32 9.9 0 top
TP175  THRU HOLE  [TP_40X65]  265.38 165.67 0 top
TP176  SMD  [TP40_SMD]  96.39 194.58 0 top
TP177  SMD  [TP40_SMD]  225.27 53.74 0 top
TP178  SMD  [TP40_SMD]  265.91 51.88 0 top
TP179  SMD  [TP40_SMD]  132.54 9.77 0 top
TP180  SMD  [TP40_SMD]  76.33 185.05 0 top
TP181  SMD  [TP40_SMD]  89.54 198.01 0 top
TP182  SMD  [TP40_SMD]  87.83 197.86 0 top
TP184  SMD  [TP40_SMD]  100.02 107.45 0 top
TP185  SMD  [TP40_SMD]  100.15 110.12 0 top
TP186  SMD  [TP40_SMD]  91.02 104.91 0 top
TP187  SMD  [TP40_SMD]  94.06 104.91 0 top
TP188  SMD  [TP40_SMD]  97.11 104.91 0 top
TP189  SMD  [TP40_SMD]  100.15 104.78 0 top
TP191  SMD  [TP40_SMD]  87.02 117.13 0 top
TP192  SMD  [TP40_SMD]  82.58 120.26 270 top
TP193  SMD  [TP40_SMD]  277.24 55.51 0 top
TP194  THRU HOLE  [TP_40X65]  227.33 237.25 0 top
TP195  THRU HOLE  [TP_40X65]  129.31 234.58 0 top
TP196  THRU HOLE  [TP_40X65]  274.88 106.47 0 top
TP197  THRU HOLE  [TP_40X65]  286.11 89.42 0 top
TP198  THRU HOLE  [TP_40X65]  291.29 94.53 0 top
TP199  THRU HOLE  [TP_40X65]  274.45 199 0 top
TP200  SMD  [TP40_SMD]  281.66 202.43 90 top
TP201  THRU HOLE  [TP_40X65]  158.6 230.11 0 top
TP202  THRU HOLE  [TP_40X65]  194.18 49.9 0 top
TP203  THRU HOLE  [TP_40X65]  110.74 204.36 0 top
TP204  THRU HOLE  [TP_40X65]  110.87 201.94 0 top
TP205  SMD  [TP40_SMD]  276.35 53.99 0 top
TP206  SMD  [TP40_SMD]  277.11 52.34 0 top
TP207  SMD  [TP40_SMD]  272.41 50.18 0 top
TP208  SMD  [TP40_SMD]  103.12 46.62 0 top
TP209  SMD  [TP40_SMD]  104.9 47 0 top
TP210  SMD  [TP40_SMD]  104.9 45.23 0 top
TP211  SMD  [TP40_SMD]  107.57 45.48 0 top
TP212  SMD  [TP40_SMD]  106.68 47 0 top
TP213  SMD  [TP40_SMD]  101.22 46.62 0 top
TP214  SMD  [TP40_SMD]  101.98 44.97 0 top
U1  X66AK2G12ABY100  [BGASKT625_31-49_1270X1270]  173.61 119.01 270 top
U2  TPS3808G33DBVR  [SOT23-6]  293.47 101.59 0 top
U3  TPD4S012DRYR  [SON6_19-68_60X45]  252.88 13.35 0 top
U4  SN74LVC1G04DCKR  [SC70-5]  288.52 101.59 270 top
U5  SN74LVC1G08DBVRE4  [SOT23-5]  224.1 243.37 270 top
U6  TPS650006RTET  [QFN16_19-68_120X120]  281.15 96.13 270 top
U7  LM22675MR-ADJ/NOPB  [ESOIC8]  132.41 228.61 270 top
U8  TPS79601DRBR  [SON8_25-59_130X130]  194.06 231.41 0 top
U9  AS4C4M16SA-6BIN  [VFBGA54_31-49_320X320]  239.24 72.84 0 top
U10  LP3985IM5-3.0/NOPB  [SOT23-5]  123.32 227.09 270 top
U11  IS25LQ010B-JNLE  [SOIC8]  261.72 62.68 0 top
U12  XC2C64A-5VQG44C  [TQFP44_31-49_400X400]  245.62 96.79 90 top
U13  MAX3221CPWR  [TSSOP16_25-59_205X180]  25.78 226.84 270 top
U14  TCA9517DGKR  [VSSOP8_25-59_120X120]  67.56 211.98 270 top
U16  TCA9517DGKR  [VSSOP8_25-59_120X120]  77.98 211.85 270 top
U17  AM1802EZWTD3  [BGA361_31-49_635X635]  241.02 51.25 0 top
U18  TPS54620RGYR  [QFN14_19-68_145X145]  263.4 213.76 90 top
U20  TM4C129XNCZADI3  [NFBGA212_19-68_400X400]  74.93 196.23 0 top
U21  32.768KHz  [OSC4_ASEK_130X110_SMD]  84.96 188.1 0 top
U22  CSD87330Q3D  [SON8_25-59_130X130_TI]  246.76 188.1 0 top
U23  SN74LVC1G11DCKR  [SC70-6]  102.23 184.42 0 top
U24  SN74AVC8T245RHL  [QFN24_19-68_225X145]  89.92 182.89 0 top
U25  LP2996AMR/NOPB  [ESOIC8]  116.97 202.71 270 top
U26  SN74LVC1G11DCKR  [SC70-6]  101.47 179.47 0 top
U27  MT41K512M8DA-107  [FBGA78_31-49_360X420]  138.05 178.45 270 top
U29  EMMC16G-S100-A06U  [FBGA153_19-68_460X515]  175.76 185.63 180 top
U30  SN74AVC4T245PW  [TSSOP16_25-59_205X180]  75.57 174 0 top
U31  SN74AVC4T245PW  [TSSOP16_25-59_205X180]  50.16 176.54 0 top
U32  TPS65911A  [BGA98_25-59_360X240]  245.49 173.12 0 top
U33  SN74AVC8T245RHL  [QFN24_19-68_225X145]  62.23 172.86 0 top
U34  SN74AVC1T45DBVR  [SOT23-6]  180.2 198.84 180 top
U35  SN74AVC8T245RHL  [QFN24_19-68_225X145]  90.17 170.96 0 top
U36  SN74LVC1G08DBVRE4  [SOT23-5]  185.41 198.71 90 top
U37  TS3L110PWG4  [TSSOP16_25-59_205X180]  219.89 78.96 180 bottom
U38  AT24CM01  [TSSOP8_25-59_125X180]  201.73 169.96 180 top
U39  MT41K512M8DA-107  [FBGA78_31-49_360X420]  138.05 163.21 270 top
U40  MT25QL128ABA8ESF-0SIT  [SOIC16_W]  199.06 183.02 180 top
U41  SN74AVC8T245RHL  [QFN24_19-68_225X145]  223.55 99.86 180 top
U42  INA226AIDGSR  [MSOP10_19-68_120X120]  272.16 150.51 0 top
U43  INA226AIDGSR  [MSOP10_19-68_120X120]  255.27 149.75 0 top
U44  INA226AIDGSR  [MSOP10_19-68_120X120]  241.68 149.49 0 top
U45  MT41K512M8DA-107  [FBGA78_31-49_360X420]  138.05 147.97 270 top
U46  INA226AIDGSR  [MSOP10_19-68_120X120]  242.06 140.35 0 top
U47  SN74LVC1G04DCKR  [SC70-5]  212.22 91.2 0 top
U48  INA226AIDGSR  [MSOP10_19-68_120X120]  254.13 139.21 0 top
U49  MT41K512M8DA-107  [FBGA78_31-49_360X420]  138.05 132.73 270 top
U50  TLV707085DQNT  [DQN_25-59_40X40]  192.15 92.22 0 top
U51  TCA9555RTWR  [QFN24_19-68_165X165]  92.48 111.32 0 top
U52  MT41K512M8DA-107  [FBGA78_31-49_360X420]  138.05 117.49 270 top
U53  TPS61081DRCT  [SON10_19-68_130X130]  43.76 75.88 270 top
U54  TPS2051BD  [SOIC8]  216.61 53.18 0 top
U56  CS2000CP-CZZ  [MSOP10_19-68_120X120]  198.37 95.52 0 top
U57  TPS2051BD  [SOIC8]  196.01 26.1 0 top
U58  SN74LVC1G08DBVRE4  [SOT23-5]  79.19 50.56 0 top
U59  SN74AVC1T45DBVR  [SOT23-6]  188.98 138.57 0 top
U60  20.000MHz  [OSC10_E6718LF_280X200_SMD]  127.76 94.63 0 top
U62  CDCM6208V2RGZT  [VQFN48_19-68_285X285]  143 89.42 0 top
U64  SN74AVC4T245PW  [TSSOP16_25-59_205X180]  198.86 149.8 90 top
U66  SN74AVC2T245RSWR  [QFN10_15-74_75X60]  178.74 93.03 90 bottom
U67  SN74AVCB164245VR  [TVSOP48_15-74_385X180]  170.61 91.25 270 top
U68  SN74LVC1G04DCKR  [SC70-5]  44.07 120.28 270 top
U69  SN74AVC4T245PW  [TSSOP16_25-59_205X180]  282.53 55.27 0 top
U71  SN74LVC1G08DBVRE4  [SOT23-5]  189.86 76.21 0 top
U72  S25FL512SAGMFI011  [SOIC16_W]  198.27 75.83 0 top
U73  TPD4S012DRYR  [SON6_19-68_60X45]  14.61 61.1 270 top
U74  CP2105-F01-GM  [QFN24_19-68_160X160]  19.94 60.97 0 top
U75  12.288MHz  [OSC4_CB3_305X205_SMD]  287.84 48.36 180 top
U76  SN74AVC2T245RSWR  [QFN10_15-74_75X60]  45.14 115.25 90 top
U78  REF5025AIDGKT  [MSOP8_25-59_125X125]  100.71 93.49 0 top
U79  DAC8550IBDGKT  [VSSOP8_25-59_120X120]  109.09 91.07 270 top
U80  SN74LVC1G04DCKR  [SC70-5]  110.49 19.47 270 top
U81  SN74LVC32244ZKER  [LFBGA96_31-49_220X540]  157.45 64.51 270 top
U82  SN74LVC32244ZKER  [LFBGA96_31-49_220X540]  132.05 64.12 270 top
U84  SN74LVC1G04DCKR  [SC70-5]  280.86 60.68 90 top
U86  SN74LVC1G04DCKR  [SC70-5]  10.79 43.58 270 top
U87  MT29F2G16ABAFAWP:F  [TSOP48_19-68_730X480]  119 118.25 90 bottom
U88  SN74LVC1G07DCK  [SC70-5]  181.53 41.16 180 top
U89  SN74LVC1G08DBVRE4  [SOT23-5]  180.64 45.48 270 top
U90  TPD4E05U06QDQARQ1  [USON10_19-68_40X100]  174.8 33.16 180 bottom
U91  SN74LVC1G08DBVRE4  [SOT23-5]  114.25 52.24 180 top
U92  KSZ9031RNXCA  [QFN48_19-68_280X280]  172.72 51.63 90 top
U93  MAX3232ECD  [SOIC16]  34.47 127.7 180 top
U94  TPD4E05U06QDQARQ1  [USON10_19-68_40X100]  168.45 33.16 180 bottom
U95  TCA9517DGKR  [VSSOP8_25-59_120X120]  293.75 37.48 90 top
U96  TLV320AIC3106IRGZT  [VQFN48_19-68_285X285]  275.59 39.64 0 top
U97  SN74LVC1G08DBVRE4  [SOT23-5]  287.3 38.93 0 top
U98  ISO1050DUB  [SOP8_100_375X260]  32.36 161.61 180 top
U100  ISO1050DUB  [SOP8_100_375X260]  27.56 197.07 180 top
U101  SN74LVC1G04DCKR  [SC70-5]  39.74 203.77 90 top
U102  SiI9022ACNU  [QFN72_19-68_395X395]  101.17 37.84 90 top
U103  TPS71712DCKR  [SC70-5]  103.71 51.81 270 top
U104  PSM712-LF-T7  [SOT23-123]  23.22 161.48 90 top
U105  PSM712-LF-T7  [SOT23-123]  18.16 196.94 90 top
U106  SN74LVC1G08DBVRE4  [SOT23-5]  130.12 27.17 0 top
U107  TPD2E001DRLR  [SOT533-5]  234.49 26.25 270 top
U108  TPD12S016PWR  [TSSOP24_25-59_315X180]  88.43 22.85 270 top
U109  TPD4S012DRYR  [SON6_19-68_60X45]  199.01 15.76 270 top
U111  TPD6E001RSER  [UQFN10_19-68_80X60]  239.06 30.44 180 bottom
U112  TMP102AIDRLT  [SOT563-6]  157.78 147.04 0 top
U115  SN74AVC8T245RHL  [QFN24_19-68_225X145]  293.82 55.44 90 top
U116  TPS54429ERSAR  [QFN16_25-59_160X160]  238.33 237.07 270 top
U118  R1Z-3.305/HP  [SMD10_R1Z_600X420]  33.89 182.82 270 top
U119  R1Z-3.305/HP  [SMD10_R1Z_600X420]  33.89 146.8 270 top
U122  SN74AVC1T45DBVR  [SOT23-6]  131.55 101.77 0 top
U123  TPS22913BYZVR  [DSBGA4_19-68_40X40]  131.32 106.69 0 top
U124  SN74AVC2T245RSWR  [QFN10_15-74_75X60]  44.95 106.42 90 top
U125  SN74AVC4T245PW  [TSSOP16_25-59_205X180]  183.74 216.14 90 top
U126  SN74AVC4T245PW  [TSSOP16_25-59_205X180]  171.04 216.3 90 top
U127  SN74LVC1G08DBVRE4  [SOT23-5]  209.02 182.41 180 top
U128  SN74AVC4T245PW  [TSSOP16_25-59_205X180]  195.33 215.97 90 top
U129  SN74AVC2T245RSWR  [QFN10_15-74_75X60]  32.95 208.27 270 top
U130  SN74AVC2T245RSWR  [QFN10_15-74_75X60]  44.45 209.17 0 top
U131  SN74LVC1G07DCK  [SC70-5]  224.54 247.49 180 top
U132  SN74AVC8T245RHL  [QFN24_19-68_225X145]  220.6 89.93 0 top
U133  TS3L110PWG4  [TSSOP16_25-59_205X180]  230.1 90.64 0 top
U134  TS3L110PWG4  [TSSOP16_25-59_205X180]  225.5 108.9 0 top
U135  SN74AVC1T45DBVR  [SOT23-6]  206.85 150.26 180 top
U136  SN74AVC4T245PW  [TSSOP16_25-59_205X180]  198.85 149.8 270 bottom
U137  SN74AVC1T45DBVR  [SOT23-6]  206.85 150.26 180 bottom
U138  SN74LVC1G11DCKR  [SC70-6]  105.92 193.94 0 top
U139  SN74CB3T1G125DBVR  [SOT23-5]  294.55 63.01 270 top
U140  SN74LVC1G07DCK  [SC70-5]  130.61 32.35 0 top
U141  TPS54429ERSAR  [QFN16_25-59_160X160]  285.22 198.87 270 top
U142  TXS0108EPWR  [TSSOP20_25-59_260X180]  211.91 210.07 0 top
U144  SN74LVC1G04DCKR  [SC70-5]  161.77 216.2 0 top
U146  SN74AVC2T245RSWR  [QFN10_15-74_75X60]  23.09 91.61 0 top
U147  SN74AVC2T245RSWR  [QFN10_15-74_75X60]  33.35 92.9 90 top
U149  LM5060MM  [MSOP10_19-68_120X120]  279.7 213.12 0 bottom
Y1  32.768KHz  [XTAL_FC-135_130X65_SMD]  259.82 55.56 270 top
Y2  24MHz  [XTAL4_ABM8G_130X105_SMD]  255.12 52.52 270 top
Y3  25.000MHz  [XTAL4_NX3225GA_130X100_SMD]  89.31 201.46 90 top
Y4  32.768KHz  [XTAL_FC-135_130X65_SMD]  260.81 175.17 270 top
Y5  22.5792MHz  [XTAL4_NX3225GA_130X100_SMD]  195.33 116.22 90 bottom
Y6  24MHz  [XTAL4_ABM8G_130X105_SMD]  153.8 110.63 90 bottom
Y7  12.288MHz  [XTAL2_ATS-SM_460X190_SMD]  200.66 89.42 180 top
Y8  24.0000MHz  [XTAL4_86-61X62-99_130X105_SMD]  136.09 78.32 180 top
Y9  25MHz  [XTAL_ABM3_205X130_SMD]  162.59 46.8 270 top

## Library data of the parts
C1-C5 C7-C21 C24-C50 C52-C76 C78-C100 C102-C114 C116-C118 C121-C127 C129-C138 C140-C152 C154-C185 C187-C240 C242-C244 C246-C269 C271-C274 C276-C280 C282-C284 C286-C288 C290-C347 C349-C397 C399-C401 C403-C496 C498 C500-C525 C527-C628 C630-C635 C637-C639 C641-C643 C645-C657 C659 C661 C663 C665-C681 C683-C704 C706-C726 C733-C735 C737-C746 C749 C750 C752-C763 C775-C778 C780-C786 C789-C813 C815-C822 C824 C826 C827 = CAP
C6 C22 C23 C51 C101 C348 C825 = CAP_POL
D2 = TLV431AQDBVR_SOT23-5
D3 D5 = DIODE_SCHOTTKY
D4 = DIODE_BAT54T1G_SOD123
D6-D13 = DIODE_PESD
D14 D15 = TPD2EUSB30D_SOT-3
D17 = DIODE_TVS_DUAL
D18 = DIODE_ZENER
D19 = DIODE
F2 = FUSE
FB1-FB3 FB5-FB9 FB11 FB13-FB15 FB17 FB19-FB49 FB51-FB53 = INDUCTOR_FERRITE
FL1 FL2 FL6 FL11 FL13-FL16 FL19 = EMIFILTER_IND
FL3 FL5 = FILTER_NFM
FL7-FL9 = EMI_LC_FILTER
J1 = CON_USB _B
J2 = CON_SCK_50X2
J3 = CON_PWRJACK3_RAPC722
J4 J49 = HEADER_6X1
J5 = CON36_PCI
J6 = HEADER_4X1
J7 = HEADER_7X2
J8 = CON_10X2
J9 J11 J15-J17 J44-J46 J48 = HEADER_3X1
J10 J13 J14 J25-J30 J39-J43 J50 = HEADER_2X1
J12 = HEADER_25X2
J18 = HEADER_5X1
J19 = CON_PMC_30X2_F
J21 = CON_FLEX_6X1_FF18
J22 = CON_FLEX_40X1_62684-4021
J23 J38 = CON_USB_MINI-AB
J31 = CON_RJ45-14_LPJG16314A4NL
J32 J33 = CON_AUDIOJACK4_SJ-2504N
J34 = CON_PMC_20X2_F
J35 = CON4_USB_A_USBR-A-S-S-O-TH
J36 = CON_HDMI_19X1
J37 = CON_SDCARD_8_DM3AT-SF-PEJM_0
JP1 = HEADER_50X2
L1-L10 = INDUCTOR
L11 L12 = IND4_P12XS43
LD1-LD15 = LED_598-8170-107F
MOD1 = MODULE_NHD-C12832A1Z
P1-P3 = CON_DSUB_9_M
Q6-Q12 Q14 Q15 Q19 = MOSFET_BSS138
Q13 = MOSFET_FDT434P_SOT223-3
Q20 = MOSFET_IRFZ24NS
R1-R4 R132 R134 R135 R319 R326 R328 R336 R343 R348 R371 R376 R377 R391 R494 R497 R504 R550 R557 R565 R636 R641 R645 R646 R661 R663 R705 R706 R709 R766 R782 R786 R844 R845 = RESISTOR: signal model: RESISTOR_RES0402_4.7K_5%_4.7K_5%
R5 R11-R16 R30-R33 R36-R38 R40 R43-R47 R52-R58 R64 R66-R69 R71-R73 R75 R76 R78 R79 R82-R85 R89 R90 R95-R108 R110-R116 R119-R125 R128 R129 R131 R138-R140 R142 R143 R149 R150 R152 R155-R158 R165 R168 R169 R171 R172 R175 R176 R178-R180 R183-R185 R187 R188 R190-R194 R196-R199 R202 R204 R216-R219 R224-R226 R228 R229 R236 R238 R239 R242 R244 R248 R249 R251-R255 R257-R260 R262-R264 R266 R268-R278 R280-R283 R286-R294 R296 R299-R302 R304 R310 R312-R318 R321 R330 R333 R334 R339 R344-R347 R349-R353 R355 R357 R359 R360 R368 R369 R378 R379 R381 R383 R385 R386 R403 R426 R429 R431 R438 R442 R443 R455 R457 R461 R474 R475 R478 R479 R483 R485-R487 R490-R492 R495 R498 R499 R501-R503 R515 R518 R520 R523 R526-R528 R530 R531 R533-R536 R539-R541 R543-R545 R548 R552 R555 R556 R559 R562 R566-R568 R570-R577 R580-R586 R588 R589 R591 R592 R594 R597-R601 R603 R604 R607-R615 R617 R621-R626 R633 R637 R638 R640 R642-R644 R647 R649-R655 R657-R660 R662 R664 R665 R668 R672 R675 R677 R683 R684 R686 R689 R690 R693 R694 R696-R699 R701 R702 R704 R712 R717-R719 R722 R723 R726 R727 R729-R738 R741-R757 R759-R761 R763-R765 R767-R770 R773-R780 R783-R785 R787 R793 R796 R802 R808 R809 R812 R813 R824-R827 R829 R830 R832-R843 R846-R863 R865 R867-R874 R876 R878-R905 R907-R915 R917-R927 = RESISTOR
R17-R24 R34 R39 R41 R42 R48-R51 R59-R63 R65 R109 R117 R118 R153 R154 R160-R164 R166 R167 R170 R174 R177 R181 R182 R195 R200 R203 R220-R223 R227 R231 R232 R240 R243 R245 R265 R267 R284 R298 R311 R324 R325 R338 R340-R342 R354 R365 R366 R370 R373 R374 R387 R388 R393 R394 R396 R398 R401 R402 R404 R405 R407-R425 R427 R428 R430 R432-R437 R439-R441 R444 R446-R448 R450-R452 R454 R456 R458-R460 R462-R464 R468-R473 R476 R477 R480-R482 R488 R489 R493 R496 R500 R511-R514 R517 R521 R522 R529 R537 R542 R547 R553 R558 R561 R563 R564 R578 R579 R590 R593 R595 R596 R602 R605 R606 R630 R635 R666 R667 R670 R671 R673 R674 R676 R679 R680 R682 R685 R688 R691 R692 R695 R700 R703 R707 R708 R710 R711 R713-R716 R720 R724 R725 R728 R758 R762 R771 R772 R788-R792 R800 R801 R803 R804 R806 R807 R814-R823 R828 R864 R875 = RESISTOR: signal model: RESISTOR_RES0402_0E_1%_0E_1%
R35 = VARISTOR
R77 R80 R81 R126 R127 R130 R136 R144-R148 R173 R189 R206-R215 R230 R233 R237 R241 R247 R256 R261 R279 R285 R295 R305-R309 R678 R681 R687 = RESISTOR: signal model: RESISTOR_RES0402_47E_1%_47E_1%
R86-R88 R91-R94 R133 R141 R205 R323 R329 R445 R449 R453 R465-R467 R507-R510 R532 R538 R546 R549 R554 R560 R616 R618-R620 R639 R866 = RESISTOR: signal model: RESISTOR_RES0402_22E_1%_22E_1%
R322 R327 R358 R362 R364 R721 R740 R781 R877 = RESISTOR: signal model: RESISTOR_RES0402_10E_10E
RA1-RA5 RA11-RA14 = RESARR_ISO4: signal model: RESARR_ISO4_RESA_0402-4_22E_22E
RA6 RA7 RA10 RA15 = RESARR_ISO4: signal model: RESARR_ISO4_RESA_0402-4_0E_0E
RA8 RA9 = RESARR_ISO8_0402: signal model: RESARR_ISO8_0402_RESA_0402-8_0E_0E
RA16 = RESARR_ISO4
RA17 = RESARR_ISO4: signal model: RESARR_ISO4_RESA_0402-4_10E_10E
RA18 RA19 = RESARR_ISO8_0402: signal model: RESARR_ISO8_0402_RESA_0402-8_10_10E
SW1 = SW3_SPST_500A
SW2 SW4-SW10 = SWTACT_1_EVQQ2
SW3 = SW8_GDH04S04
SW11-SW15 = SW2
TP9 TP13-TP23 TP25 TP26 TP29-TP31 TP33-TP59 TP61-TP82 TP84-TP86 TP88-TP98 TP100-TP104 TP106-TP129 TP131-TP133 TP135 TP136 TP138-TP147 TP149-TP155 TP157-TP182 TP184-TP189 TP191-TP214 = TESTPOINT
U1 = 66AK2G02_BGA625
U2 = TPS3808G33DBV_SOT23-6
U3 U73 U109 = TPD4S012DRY_SON6
U4 U47 U68 U80 U84 U86 U101 U144 = SN74LVC1G04DCKR_SC70-5
U5 U36 U58 U71 U89 U91 U97 U106 U127 = SN74LVC1G08DBVRE4_SOT23-5
U6 = TPS650006RTET_QFN16
U7 = LM22675MRE_SOIC8
U8 = TPS79601DRBR_SON8
U9 = MT48LC4M16A2B4_VFBGA54
U10 = LP3985IM5-2.5_SOT23-5
U11 = IS25CD010-JNLE_SOIC8
U12 = XC2C64A-5VQ44C_TQFP44
U13 = MAX3221CPWR_TSSOP16
U14 U16 U95 = TCA9517DGKR_VSSOP8
U17 = AM1802BZWTD3_BGA361
U18 = TPS54620_QFN14
U20 = TM4C129XNCZAD_NFBGA212
U21 = OSC_TGOV
U22 = MOSFET_CSD87330Q3D
U23 U26 U138 = SN74LVC1G11DCKR_SC70-6
U24 U33 U35 U41 U115 U132 = SN74AVC8T245RHL_QFN24
U25 = LP2996MR_PSOP8
U27 U39 U45 U49 U52 = MT41J128M8JP-125_FBGA78
U29 = THGBM5G5A1JBAIR_VFBGA153
U30 U31 U64 U69 U125 U126 U128 U136 = SN74AVC4T245PW_TSSOP16
U32 = TPS659113A2_BGA98_9
U34 U59 U122 U135 U137 = SN74AVC1T45DBVR_SOT23-6
U37 U133 U134 = TS3L110PWG4_TSSOP16
U38 = AT24HC04B-TH-B_TSSOP8
U40 = N25Q256A83ESF_SOP2-16
U42-U44 U46 U48 = INA226AIDGS_MSOP10
U50 = TLV707085DQNT_SMD
U51 = TCA9555RTWR_WQFN24
U53 = TPS61081DRCT_SON10
U54 U57 = TPS2051BD_SOIC8
U56 = CS2000CP-CZZ_MSOP10
U60 = OSC_E6718LF
U62 = CDCM6208V_VQFN48
U66 U76 U124 U129 U130 U146 U147 = SN74AVC2T245RSWR_QFN10
U67 = SN74AVCB164245VR_TVSOP48
U72 = S25FL512SAGMFI011_SOIC16
U74 = CP2105-F01-GM_QFN24
U75 = OSC_CB3LV_SMD4
U78 = REF5025IDGKT_MSOP8
U79 = DAC8550IBD_VSSOP8
U81 U82 = SN74LVC32244Z_LFBGA96
U87 = MT29F2G16ABAEAWP_TSOP48
U88 U131 U140 = SN74LVC1G07DBVR_SOT23-5
U90 U94 = TPD4E05U06_USON10
U92 = KSZ9031RNX_QFN48
U93 = MAX3232CDR_SOIC16
U96 = TLV320AIC3106IRGZT_VQFN48
U98 U100 = ISO1050DUB_SOP8
U102 = SiI9022ACNU_QFN72
U103 = TPS71711DCKR_SC70-5
U104 U105 = PSM712_SOT23-3
U107 = TPD2E001DRLR_SOT-5
U108 = TPD12S016PW_TSSOP24
U111 = TPD6E001RSE_UQFN10
U112 = TMP102AIDRLT_SOT563-6
U116 U141 = TPS54429ERSAR_QFN16
U118 U119 = R1Z-3.305/HP_SMD10
U123 = TPS22907YZTR_DSBGA4
U139 = SN74LVC1G125_SOT23-5
U142 = TXS0108EPW_TSSOP20
U149 = LM5060_MSOP10
Y1 Y4 Y7 Y9 = CRY
Y2 Y6 = CRY4_ABM8G
Y3 Y5 = CRY_CX3225GB
Y8 = CRY4_13

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
BGA98_25-59_360X240
  round 1.016 smd: (-3.937,5.461) (3.937,-5.461)
  round 0.254 smd: A1(-2.275,3.9) A2(-1.625,3.9) A3(-0.975,3.9) A4(-0.325,3.9) A5(0.325,3.9) A6(0.975,3.9) A7(1.625,3.9) A8(2.275,3.9) B1(-2.275,3.25) B2(-1.625,3.25) B3(-0.975,3.25) B4(-0.325,3.25) B5(0.325,3.25) B6(0.975,3.25) B7(1.625,3.25) B8(2.275,3.25) C1(-2.275,2.6) C2(-1.625,2.6) C4(-0.325,2.6) C5(0.325,2.6) C6(0.975,2.6) C7(1.625,2.6) C8(2.275,2.6) D1(-2.275,1.95) D2(-1.625,1.95) D3(-0.975,1.95) D4(-0.325,1.95) D5(0.325,1.95) D6(0.975,1.95) D7(1.625,1.95) D8(2.275,1.95) E1(-2.275,1.3) E2(-1.625,1.3) E4(-0.325,1.3) E5(0.325,1.3) E6(0.975,1.3) E7(1.625,1.3) E8(2.275,1.3) F1(-2.275,0.65) F2(-1.625,0.65) F3(-0.975,0.65) F4(-0.325,0.65) F5(0.325,0.65) F6(0.975,0.65) F7(1.625,0.65) F8(2.275,0.65) G1(-2.275,0) G2(-1.625,0) G3(-0.975,0) G4(-0.325,0) G6(0.975,0) G7(1.625,0) G8(2.275,0) H1(-2.275,-0.65) H2(-1.625,-0.65) H4(-0.325,-0.65) H5(0.325,-0.65) H6(0.975,-0.65) H7(1.625,-0.65) H8(2.275,-0.65) J1(-2.275,-1.3) J2(-1.625,-1.3) J3(-0.975,-1.3) J4(-0.325,-1.3) J5(0.325,-1.3) J6(0.975,-1.3) J7(1.625,-1.3) J8(2.275,-1.3) K1(-2.275,-1.95) K2(-1.625,-1.95) K3(-0.975,-1.95) K5(0.325,-1.95) K7(1.625,-1.95) K8(2.275,-1.95) L1(-2.275,-2.6) L2(-1.625,-2.6) L3(-0.975,-2.6) L4(-0.325,-2.6) L5(0.325,-2.6) L6(0.975,-2.6) L7(1.625,-2.6) L8(2.275,-2.6) M1(-2.275,-3.25) M2(-1.625,-3.25) M3(-0.975,-3.25) M4(-0.325,-3.25) M5(0.325,-3.25) M6(0.975,-3.25) M7(1.625,-3.25) M8(2.275,-3.25) N1(-2.275,-3.9) N2(-1.625,-3.9) N3(-0.975,-3.9) N4(-0.325,-3.9) N5(0.325,-3.9) N6(0.975,-3.9) N7(1.625,-3.9) N8(2.275,-3.9)
BGA361_31-49_635X635
  round 1.016 smd: (-9.271,9.271) (9.271,-9.271)
  round 0.406 smd: A1(-7.2,7.2) A2(-6.4,7.2) A3(-5.6,7.2) A4(-4.8,7.2) A5(-4,7.2) A6(-3.2,7.2) A7(-2.4,7.2) A8(-1.6,7.2) A9(-0.8,7.2) A10(0,7.2) A11(0.8,7.2) A12(1.6,7.2) A13(2.4,7.2) A14(3.2,7.2) A15(4,7.2) A16(4.8,7.2) A17(5.6,7.2) A18(6.4,7.2) A19(7.2,7.2) B1(-7.2,6.4) B2(-6.4,6.4) B3(-5.6,6.4) B4(-4.8,6.4) B5(-4,6.4) B6(-3.2,6.4) B7(-2.4,6.4) B8(-1.6,6.4) B9(-0.8,6.4) B10(0,6.4) B11(0.8,6.4) B12(1.6,6.4) B13(2.4,6.4) B14(3.2,6.4) B15(4,6.4) B16(4.8,6.4) B17(5.6,6.4) B18(6.4,6.4) B19(7.2,6.4) C1(-7.2,5.6) C2(-6.4,5.6) C3(-5.6,5.6) C4(-4.8,5.6) C5(-4,5.6) C6(-3.2,5.6) C7(-2.4,5.6) C8(-1.6,5.6) C9(-0.8,5.6) C10(0,5.6) C11(0.8,5.6) C12(1.6,5.6) C13(2.4,5.6) C14(3.2,5.6) C15(4,5.6) C16(4.8,5.6) C17(5.6,5.6) C18(6.4,5.6) C19(7.2,5.6) D1(-7.2,4.8) D2(-6.4,4.8) D3(-5.6,4.8) D4(-4.8,4.8) D5(-4,4.8) D6(-3.2,4.8) D7(-2.4,4.8) D8(-1.6,4.8) D9(-0.8,4.8) D10(0,4.8) D11(0.8,4.8) D12(1.6,4.8) D13(2.4,4.8) D14(3.2,4.8) D15(4,4.8) D16(4.8,4.8) D17(5.6,4.8) D18(6.4,4.8) D19(7.2,4.8) E1(-7.2,4) E2(-6.4,4) E3(-5.6,4) E4(-4.8,4) E5(-4,4) E6(-3.2,4) E7(-2.4,4) E8(-1.6,4) E9(-0.8,4) E10(0,4) E11(0.8,4) E12(1.6,4) E13(2.4,4) E14(3.2,4) E15(4,4) E16(4.8,4) E17(5.6,4) E18(6.4,4) E19(7.2,4) F1(-7.2,3.2) F2(-6.4,3.2) F3(-5.6,3.2) F4(-4.8,3.2) F5(-4,3.2) F6(-3.2,3.2) F7(-2.4,3.2) F8(-1.6,3.2) F9(-0.8,3.2) F10(0,3.2) F11(0.8,3.2) F12(1.6,3.2) F13(2.4,3.2) F14(3.2,3.2) F15(4,3.2) F16(4.8,3.2) F17(5.6,3.2) F18(6.4,3.2) F19(7.2,3.2) G1(-7.2,2.4) G2(-6.4,2.4) G3(-5.6,2.4) G4(-4.8,2.4) G5(-4,2.4) G6(-3.2,2.4) G7(-2.4,2.4) G8(-1.6,2.4) G9(-0.8,2.4) G10(0,2.4) G11(0.8,2.4) G12(1.6,2.4) G13(2.4,2.4) G14(3.2,2.4) G15(4,2.4) G16(4.8,2.4) G17(5.6,2.4) G18(6.4,2.4) G19(7.2,2.4) H1(-7.2,1.6) H2(-6.4,1.6) H3(-5.6,1.6) H4(-4.8,1.6) H5(-4,1.6) H6(-3.2,1.6) H7(-2.4,1.6) H8(-1.6,1.6) H9(-0.8,1.6) H10(0,1.6) H11(0.8,1.6) H12(1.6,1.6) H13(2.4,1.6) H14(3.2,1.6) H15(4,1.6) H16(4.8,1.6) H17(5.6,1.6) H18(6.4,1.6) H19(7.2,1.6) J1(-7.2,0.8) J2(-6.4,0.8) J3(-5.6,0.8) J4(-4.8,0.8) J5(-4,0.8) J6(-3.2,0.8) J7(-2.4,0.8) J8(-1.6,0.8) J9(-0.8,0.8) J10(0,0.8) J11(0.8,0.8) J12(1.6,0.8) J13(2.4,0.8) J14(3.2,0.8) J15(4,0.8) J16(4.8,0.8) J17(5.6,0.8) J18(6.4,0.8) J19(7.2,0.8) K1(-7.2,0) K2(-6.4,0) K3(-5.6,0) K4(-4.8,0) K5(-4,0) K6(-3.2,0) K7(-2.4,0) K8(-1.6,0) K9(-0.8,0) K10(0,0) K11(0.8,0) K12(1.6,0) K13(2.4,0) K14(3.2,0) K15(4,0) K16(4.8,0) K17(5.6,0) K18(6.4,0) K19(7.2,0) L1(-7.2,-0.8) L2(-6.4,-0.8) L3(-5.6,-0.8) L4(-4.8,-0.8) L5(-4,-0.8) L6(-3.2,-0.8) L7(-2.4,-0.8) L8(-1.6,-0.8) L9(-0.8,-0.8) L10(0,-0.8) L11(0.8,-0.8) L12(1.6,-0.8) L13(2.4,-0.8) L14(3.2,-0.8) L15(4,-0.8) L16(4.8,-0.8) L17(5.6,-0.8) L18(6.4,-0.8) L19(7.2,-0.8) M1(-7.2,-1.6) M2(-6.4,-1.6) M3(-5.6,-1.6) M4(-4.8,-1.6) M5(-4,-1.6) M6(-3.2,-1.6) M7(-2.4,-1.6) M8(-1.6,-1.6) M9(-0.8,-1.6) M10(0,-1.6) M11(0.8,-1.6) M12(1.6,-1.6) M13(2.4,-1.6) M14(3.2,-1.6) M15(4,-1.6) M16(4.8,-1.6) M17(5.6,-1.6) M18(6.4,-1.6) M19(7.2,-1.6) N1(-7.2,-2.4) N2(-6.4,-2.4) N3(-5.6,-2.4) N4(-4.8,-2.4) N5(-4,-2.4) N6(-3.2,-2.4) N7(-2.4,-2.4) N8(-1.6,-2.4) N9(-0.8,-2.4) N10(0,-2.4) N11(0.8,-2.4) N12(1.6,-2.4) N13(2.4,-2.4) N14(3.2,-2.4) N15(4,-2.4) N16(4.8,-2.4) N17(5.6,-2.4) N18(6.4,-2.4) N19(7.2,-2.4) P1(-7.2,-3.2) P2(-6.4,-3.2) P3(-5.6,-3.2) P4(-4.8,-3.2) P5(-4,-3.2) P6(-3.2,-3.2) P7(-2.4,-3.2) P8(-1.6,-3.2) P9(-0.8,-3.2) P10(0,-3.2) P11(0.8,-3.2) P12(1.6,-3.2) P13(2.4,-3.2) P14(3.2,-3.2) P15(4,-3.2) P16(4.8,-3.2) P17(5.6,-3.2) P18(6.4,-3.2) P19(7.2,-3.2) R1(-7.2,-4) R2(-6.4,-4) R3(-5.6,-4) R4(-4.8,-4) R5(-4,-4) R6(-3.2,-4) R7(-2.4,-4) R8(-1.6,-4) R9(-0.8,-4) R10(0,-4) R11(0.8,-4) R12(1.6,-4) R13(2.4,-4) R14(3.2,-4) R15(4,-4) R16(4.8,-4) R17(5.6,-4) R18(6.4,-4) R19(7.2,-4) T1(-7.2,-4.8) T2(-6.4,-4.8) T3(-5.6,-4.8) T4(-4.8,-4.8) T5(-4,-4.8) T6(-3.2,-4.8) T7(-2.4,-4.8) T8(-1.6,-4.8) T9(-0.8,-4.8) T10(0,-4.8) T11(0.8,-4.8) T12(1.6,-4.8) T13(2.4,-4.8) T14(3.2,-4.8) T15(4,-4.8) T16(4.8,-4.8) T17(5.6,-4.8) T18(6.4,-4.8) T19(7.2,-4.8) U1(-7.2,-5.6) U2(-6.4,-5.6) U3(-5.6,-5.6) U4(-4.8,-5.6) U5(-4,-5.6) U6(-3.2,-5.6) U7(-2.4,-5.6) U8(-1.6,-5.6) U9(-0.8,-5.6) U10(0,-5.6) U11(0.8,-5.6) U12(1.6,-5.6) U13(2.4,-5.6) U14(3.2,-5.6) U15(4,-5.6) U16(4.8,-5.6) U17(5.6,-5.6) U18(6.4,-5.6) U19(7.2,-5.6) V1(-7.2,-6.4) V2(-6.4,-6.4) V3(-5.6,-6.4) V4(-4.8,-6.4) V5(-4,-6.4) V6(-3.2,-6.4) V7(-2.4,-6.4) V8(-1.6,-6.4) V9(-0.8,-6.4) V10(0,-6.4) V11(0.8,-6.4) V12(1.6,-6.4) V13(2.4,-6.4) V14(3.2,-6.4) V15(4,-6.4) V16(4.8,-6.4) V17(5.6,-6.4) V18(6.4,-6.4) V19(7.2,-6.4) W1(-7.2,-7.2) W2(-6.4,-7.2) W3(-5.6,-7.2) W4(-4.8,-7.2) W5(-4,-7.2) W6(-3.2,-7.2) W7(-2.4,-7.2) W8(-1.6,-7.2) W9(-0.8,-7.2) W10(0,-7.2) W11(0.8,-7.2) W12(1.6,-7.2) W13(2.4,-7.2) W14(3.2,-7.2) W15(4,-7.2) W16(4.8,-7.2) W17(5.6,-7.2) W18(6.4,-7.2) W19(7.2,-7.2)
BGASKT625_31-49_1270X1270
  round 3.124 hole 3.251 unplated: (-14.24,13.86) (-14.24,-13.87) (13.49,13.86) (13.49,-13.87)
  round 0.737 hole 0.864 unplated: (-14.24,-6.37) (13.49,8.86)
  round 0.457 smd: A1(-9.6,9.6) A2(-8.8,9.6) A3(-8,9.6) A4(-7.2,9.6) A5(-6.4,9.6) A6(-5.6,9.6) A7(-4.8,9.6) A8(-4,9.6) A9(-3.2,9.6) A10(-2.4,9.6) A11(-1.6,9.6) A12(-0.8,9.6) A13(0,9.6) A14(0.8,9.6) A15(1.6,9.6) A16(2.4,9.6) A17(3.2,9.6) A18(4,9.6) A19(4.8,9.6) A20(5.6,9.6) A21(6.4,9.6) A22(7.2,9.6) A23(8,9.6) A24(8.8,9.6) A25(9.6,9.6) AA1(-9.6,-6.4) AA2(-8.8,-6.4) AA3(-8,-6.4) AA4(-7.2,-6.4) AA5(-6.4,-6.4) AA6(-5.6,-6.4) AA7(-4.8,-6.4) AA8(-4,-6.4) AA9(-3.2,-6.4) AA10(-2.4,-6.4) AA11(-1.6,-6.4) AA12(-0.8,-6.4) AA13(0,-6.4) AA14(0.8,-6.4) AA15(1.6,-6.4) AA16(2.4,-6.4) AA17(3.2,-6.4) AA18(4,-6.4) AA19(4.8,-6.4) AA20(5.6,-6.4) AA21(6.4,-6.4) AA22(7.2,-6.4) AA23(8,-6.4) AA24(8.8,-6.4) AA25(9.6,-6.4) AB1(-9.6,-7.2) AB2(-8.8,-7.2) AB3(-8,-7.2) AB4(-7.2,-7.2) AB5(-6.4,-7.2) AB6(-5.6,-7.2) AB7(-4.8,-7.2) AB8(-4,-7.2) AB9(-3.2,-7.2) AB10(-2.4,-7.2) AB11(-1.6,-7.2) AB12(-0.8,-7.2) AB13(0,-7.2) AB14(0.8,-7.2) AB15(1.6,-7.2) AB16(2.4,-7.2) AB17(3.2,-7.2) AB18(4,-7.2) AB19(4.8,-7.2) AB20(5.6,-7.2) AB21(6.4,-7.2) AB22(7.2,-7.2) AB23(8,-7.2) AB24(8.8,-7.2) AB25(9.6,-7.2) AC1(-9.6,-8) AC2(-8.8,-8) AC3(-8,-8) AC4(-7.2,-8) AC5(-6.4,-8) AC6(-5.6,-8) AC7(-4.8,-8) AC8(-4,-8) AC9(-3.2,-8) AC10(-2.4,-8) AC11(-1.6,-8) AC12(-0.8,-8) AC13(0,-8) AC14(0.8,-8) AC15(1.6,-8) AC16(2.4,-8) AC17(3.2,-8) AC18(4,-8) AC19(4.8,-8) AC20(5.6,-8) AC21(6.4,-8) AC22(7.2,-8) AC23(8,-8) AC24(8.8,-8) AC25(9.6,-8) AD1(-9.6,-8.8) AD2(-8.8,-8.8) AD3(-8,-8.8) AD4(-7.2,-8.8) AD5(-6.4,-8.8) AD6(-5.6,-8.8) AD7(-4.8,-8.8) AD8(-4,-8.8) AD9(-3.2,-8.8) AD10(-2.4,-8.8) AD11(-1.6,-8.8) AD12(-0.8,-8.8) AD13(0,-8.8) AD14(0.8,-8.8) AD15(1.6,-8.8) AD16(2.4,-8.8) AD17(3.2,-8.8) AD18(4,-8.8) AD19(4.8,-8.8) AD20(5.6,-8.8) AD21(6.4,-8.8) AD22(7.2,-8.8) AD23(8,-8.8) AD24(8.8,-8.8) AD25(9.6,-8.8) AE1(-9.6,-9.6) AE2(-8.8,-9.6) AE3(-8,-9.6) AE4(-7.2,-9.6) AE5(-6.4,-9.6) AE6(-5.6,-9.6) AE7(-4.8,-9.6) AE8(-4,-9.6) AE9(-3.2,-9.6) AE10(-2.4,-9.6) AE11(-1.6,-9.6) AE12(-0.8,-9.6) AE13(0,-9.6) AE14(0.8,-9.6) AE15(1.6,-9.6) AE16(2.4,-9.6) AE17(3.2,-9.6) AE18(4,-9.6) AE19(4.8,-9.6) AE20(5.6,-9.6) AE21(6.4,-9.6) AE22(7.2,-9.6) AE23(8,-9.6) AE24(8.8,-9.6) AE25(9.6,-9.6) B1(-9.6,8.8) B2(-8.8,8.8) B3(-8,8.8) B4(-7.2,8.8) B5(-6.4,8.8) B6(-5.6,8.8) B7(-4.8,8.8) B8(-4,8.8) B9(-3.2,8.8) B10(-2.4,8.8) B11(-1.6,8.8) B12(-0.8,8.8) B13(0,8.8) B14(0.8,8.8) B15(1.6,8.8) B16(2.4,8.8) B17(3.2,8.8) B18(4,8.8) B19(4.8,8.8) B20(5.6,8.8) B21(6.4,8.8) B22(7.2,8.8) B23(8,8.8) B24(8.8,8.8) B25(9.6,8.8) C1(-9.6,8) C2(-8.8,8) C3(-8,8) C4(-7.2,8) C5(-6.4,8) C6(-5.6,8) C7(-4.8,8) C8(-4,8) C9(-3.2,8) C10(-2.4,8) C11(-1.6,8) C12(-0.8,8) C13(0,8) C14(0.8,8) C15(1.6,8) C16(2.4,8) C17(3.2,8) C18(4,8) C19(4.8,8) C20(5.6,8) C21(6.4,8) C22(7.2,8) C23(8,8) C24(8.8,8) C25(9.6,8) D1(-9.6,7.2) D2(-8.8,7.2) D3(-8,7.2) D4(-7.2,7.2) D5(-6.4,7.2) D6(-5.6,7.2) D7(-4.8,7.2) D8(-4,7.2) D9(-3.2,7.2) D10(-2.4,7.2) D11(-1.6,7.2) D12(-0.8,7.2) D13(0,7.2) D14(0.8,7.2) D15(1.6,7.2) D16(2.4,7.2) D17(3.2,7.2) D18(4,7.2) D19(4.8,7.2) D20(5.6,7.2) D21(6.4,7.2) D22(7.2,7.2) D23(8,7.2) D24(8.8,7.2) D25(9.6,7.2) E1(-9.6,6.4) E2(-8.8,6.4) E3(-8,6.4) E4(-7.2,6.4) E5(-6.4,6.4) E6(-5.6,6.4) E7(-4.8,6.4) E8(-4,6.4) E9(-3.2,6.4) E10(-2.4,6.4) E11(-1.6,6.4) E12(-0.8,6.4) E13(0,6.4) E14(0.8,6.4) E15(1.6,6.4) E16(2.4,6.4) E17(3.2,6.4) E18(4,6.4) E19(4.8,6.4) E20(5.6,6.4) E21(6.4,6.4) E22(7.2,6.4) E23(8,6.4) E24(8.8,6.4) E25(9.6,6.4) F1(-9.6,5.6) F2(-8.8,5.6) F3(-8,5.6) F4(-7.2,5.6) F5(-6.4,5.6) F6(-5.6,5.6) F7(-4.8,5.6) F8(-4,5.6) F9(-3.2,5.6) F10(-2.4,5.6) F11(-1.6,5.6) F12(-0.8,5.6) F13(0,5.6) F14(0.8,5.6) F15(1.6,5.6) F16(2.4,5.6) F17(3.2,5.6) F18(4,5.6) F19(4.8,5.6) F20(5.6,5.6) F21(6.4,5.6) F22(7.2,5.6) F23(8,5.6) F24(8.8,5.6) F25(9.6,5.6) G1(-9.6,4.8) G2(-8.8,4.8) G3(-8,4.8) G4(-7.2,4.8) G5(-6.4,4.8) G6(-5.6,4.8) G7(-4.8,4.8) G8(-4,4.8) G9(-3.2,4.8) G10(-2.4,4.8) G11(-1.6,4.8) G12(-0.8,4.8) G13(0,4.8) G14(0.8,4.8) G15(1.6,4.8) G16(2.4,4.8) G17(3.2,4.8) G18(4,4.8) G19(4.8,4.8) G20(5.6,4.8) G21(6.4,4.8) G22(7.2,4.8) G23(8,4.8) G24(8.8,4.8) G25(9.6,4.8) H1(-9.6,4) H2(-8.8,4) H3(-8,4) H4(-7.2,4) H5(-6.4,4) H6(-5.6,4) H7(-4.8,4) H8(-4,4) H9(-3.2,4) H10(-2.4,4) H11(-1.6,4) H12(-0.8,4) H13(0,4) H14(0.8,4) H15(1.6,4) H16(2.4,4) H17(3.2,4) H18(4,4) H19(4.8,4) H20(5.6,4) H21(6.4,4) H22(7.2,4) H23(8,4) H24(8.8,4) H25(9.6,4) J1(-9.6,3.2) J2(-8.8,3.2) J3(-8,3.2) J4(-7.2,3.2) J5(-6.4,3.2) J6(-5.6,3.2) J7(-4.8,3.2) J8(-4,3.2) J9(-3.2,3.2) J10(-2.4,3.2) J11(-1.6,3.2) J12(-0.8,3.2) J13(0,3.2) J14(0.8,3.2) J15(1.6,3.2) J16(2.4,3.2) J17(3.2,3.2) J18(4,3.2) J19(4.8,3.2) J20(5.6,3.2) J21(6.4,3.2) J22(7.2,3.2) J23(8,3.2) J24(8.8,3.2) J25(9.6,3.2) K1(-9.6,2.4) K2(-8.8,2.4) K3(-8,2.4) K4(-7.2,2.4) K5(-6.4,2.4) K6(-5.6,2.4) K7(-4.8,2.4) K8(-4,2.4) K9(-3.2,2.4) K10(-2.4,2.4) K11(-1.6,2.4) K12(-0.8,2.4) K13(0,2.4) K14(0.8,2.4) K15(1.6,2.4) K16(2.4,2.4) K17(3.2,2.4) K18(4,2.4) K19(4.8,2.4) K20(5.6,2.4) K21(6.4,2.4) K22(7.2,2.4) K23(8,2.4) K24(8.8,2.4) K25(9.6,2.4) L1(-9.6,1.6) L2(-8.8,1.6) L3(-8,1.6) L4(-7.2,1.6) L5(-6.4,1.6) L6(-5.6,1.6) L7(-4.8,1.6) L8(-4,1.6) L9(-3.2,1.6) L10(-2.4,1.6) L11(-1.6,1.6) L12(-0.8,1.6) L13(0,1.6) L14(0.8,1.6) L15(1.6,1.6) L16(2.4,1.6) L17(3.2,1.6) L18(4,1.6) L19(4.8,1.6) L20(5.6,1.6) L21(6.4,1.6) L22(7.2,1.6) L23(8,1.6) L24(8.8,1.6) L25(9.6,1.6) M1(-9.6,0.8) M2(-8.8,0.8) M3(-8,0.8) M4(-7.2,0.8) M5(-6.4,0.8) M6(-5.6,0.8) M7(-4.8,0.8) M8(-4,0.8) M9(-3.2,0.8) M10(-2.4,0.8) M11(-1.6,0.8) M12(-0.8,0.8) M13(0,0.8) M14(0.8,0.8) M15(1.6,0.8) M16(2.4,0.8) M17(3.2,0.8) M18(4,0.8) M19(4.8,0.8) M20(5.6,0.8) M21(6.4,0.8) M22(7.2,0.8) M23(8,0.8) M24(8.8,0.8) M25(9.6,0.8) N1(-9.6,0) N2(-8.8,0) N3(-8,0) N4(-7.2,0) N5(-6.4,0) N6(-5.6,0) N7(-4.8,0) N8(-4,0) N9(-3.2,0) N10(-2.4,0) N11(-1.6,0) N12(-0.8,0) N13(0,0) N14(0.8,0) N15(1.6,0) N16(2.4,0) N17(3.2,0) N18(4,0) N19(4.8,0) N20(5.6,0) N21(6.4,0) N22(7.2,0) N23(8,0) N24(8.8,0) N25(9.6,0) P1(-9.6,-0.8) P2(-8.8,-0.8) P3(-8,-0.8) P4(-7.2,-0.8) P5(-6.4,-0.8) P6(-5.6,-0.8) P7(-4.8,-0.8) P8(-4,-0.8) P9(-3.2,-0.8) P10(-2.4,-0.8) P11(-1.6,-0.8) P12(-0.8,-0.8) P13(0,-0.8) P14(0.8,-0.8) P15(1.6,-0.8) P16(2.4,-0.8) P17(3.2,-0.8) P18(4,-0.8) P19(4.8,-0.8) P20(5.6,-0.8) P21(6.4,-0.8) P22(7.2,-0.8) P23(8,-0.8) P24(8.8,-0.8) P25(9.6,-0.8) R1(-9.6,-1.6) R2(-8.8,-1.6) R3(-8,-1.6) R4(-7.2,-1.6) R5(-6.4,-1.6) R6(-5.6,-1.6) R7(-4.8,-1.6) R8(-4,-1.6) R9(-3.2,-1.6) R10(-2.4,-1.6) R11(-1.6,-1.6) R12(-0.8,-1.6) R13(0,-1.6) R14(0.8,-1.6) R15(1.6,-1.6) R16(2.4,-1.6) R17(3.2,-1.6) R18(4,-1.6) R19(4.8,-1.6) R20(5.6,-1.6) R21(6.4,-1.6) R22(7.2,-1.6) R23(8,-1.6) R24(8.8,-1.6) R25(9.6,-1.6) T1(-9.6,-2.4) T2(-8.8,-2.4) T3(-8,-2.4) T4(-7.2,-2.4) T5(-6.4,-2.4) T6(-5.6,-2.4) T7(-4.8,-2.4) T8(-4,-2.4) T9(-3.2,-2.4) T10(-2.4,-2.4) T11(-1.6,-2.4) T12(-0.8,-2.4) T13(0,-2.4) T14(0.8,-2.4) T15(1.6,-2.4) T16(2.4,-2.4) T17(3.2,-2.4) T18(4,-2.4) T19(4.8,-2.4) T20(5.6,-2.4) T21(6.4,-2.4) T22(7.2,-2.4) T23(8,-2.4) T24(8.8,-2.4) T25(9.6,-2.4) U1(-9.6,-3.2) U2(-8.8,-3.2) U3(-8,-3.2) U4(-7.2,-3.2) U5(-6.4,-3.2) U6(-5.6,-3.2) U7(-4.8,-3.2) U8(-4,-3.2) U9(-3.2,-3.2) U10(-2.4,-3.2) U11(-1.6,-3.2) U12(-0.8,-3.2) U13(0,-3.2) U14(0.8,-3.2) U15(1.6,-3.2) U16(2.4,-3.2) U17(3.2,-3.2) U18(4,-3.2) U19(4.8,-3.2) U20(5.6,-3.2) U21(6.4,-3.2) U22(7.2,-3.2) U23(8,-3.2) U24(8.8,-3.2) U25(9.6,-3.2) V1(-9.6,-4) V2(-8.8,-4) V3(-8,-4) V4(-7.2,-4) V5(-6.4,-4) V6(-5.6,-4) V7(-4.8,-4) V8(-4,-4) V9(-3.2,-4) V10(-2.4,-4) V11(-1.6,-4) V12(-0.8,-4) V13(0,-4) V14(0.8,-4) V15(1.6,-4) V16(2.4,-4) V17(3.2,-4) V18(4,-4) V19(4.8,-4) V20(5.6,-4) V21(6.4,-4) V22(7.2,-4) V23(8,-4) V24(8.8,-4) V25(9.6,-4) W1(-9.6,-4.8) W2(-8.8,-4.8) W3(-8,-4.8) W4(-7.2,-4.8) W5(-6.4,-4.8) W6(-5.6,-4.8) W7(-4.8,-4.8) W8(-4,-4.8) W9(-3.2,-4.8) W10(-2.4,-4.8) W11(-1.6,-4.8) W12(-0.8,-4.8) W13(0,-4.8) W14(0.8,-4.8) W15(1.6,-4.8) W16(2.4,-4.8) W17(3.2,-4.8) W18(4,-4.8) W19(4.8,-4.8) W20(5.6,-4.8) W21(6.4,-4.8) W22(7.2,-4.8) W23(8,-4.8) W24(8.8,-4.8) W25(9.6,-4.8) Y1(-9.6,-5.6) Y2(-8.8,-5.6) Y3(-8,-5.6) Y4(-7.2,-5.6) Y5(-6.4,-5.6) Y6(-5.6,-5.6) Y7(-4.8,-5.6) Y8(-4,-5.6) Y9(-3.2,-5.6) Y10(-2.4,-5.6) Y11(-1.6,-5.6) Y12(-0.8,-5.6) Y13(0,-5.6) Y14(0.8,-5.6) Y15(1.6,-5.6) Y16(2.4,-5.6) Y17(3.2,-5.6) Y18(4,-5.6) Y19(4.8,-5.6) Y20(5.6,-5.6) Y21(6.4,-5.6) Y22(7.2,-5.6) Y23(8,-5.6) Y24(8.8,-5.6) Y25(9.6,-5.6)
CAP0201
  rect 0.457x0.432 smd: 1(-0.34,0) 2(0.34,0)
CAP0204
  rect 0.432x1.118 smd: 1(-0.31,0) 2(0.31,0)
CAP0402
  rect 0.914x0.711 smd: 1(-0.65,0) 2(0.65,0)
CAP0603
  rect 1.118x1.016 smd: 1(-0.85,0) 2(0.85,0)
CAP0805
  rect 1.143x1.448 smd: 1(-0.9,0) 2(0.9,0)
CAP1206
  rect 1.6x1.803 smd: 1(-1.4,0) 2(1.4,0)
CAP1210
  rect 1.6x2.718 smd: 1(-1.4,0) 2(1.4,0)
CAPAE_D8CASE
  rect 3.607x1.6 smd: 1(2.827,0) 2(-2.827,0)
CAPAE_ECASE
  rect 4.013x2.108 smd: 1(3.1,0) 2(-3.1,0)
CAPAE_GCASE
  rect 4.521x2.108 smd: 1(4.55,0) 2(-4.55,0)
CAPT3528B
  rect 2.007x2.21 smd: 1(-1.5,0) 2(1.5,0)
CAPT7343D
  rect 2.413x2.896 smd: 1(-3.048,0) 2(3.048,0)
CAPT7343E
  rect 2.616x2.413 smd: 1(-3.2,0) 2(3.2,0)
CON_10X2_FTR-110-51-S-D_P_S_S
  rect 0.711x2.87 smd: 1(-5.715,-2.705) 2(-5.715,2.705) 3(-4.445,-2.705) 4(-4.445,2.705) 5(-3.175,-2.705) 6(-3.175,2.705) 7(-1.905,-2.705) 8(-1.905,2.705) 9(-0.635,-2.705) 10(-0.635,2.705) 11(0.635,-2.705) 12(0.635,2.705) 13(1.905,-2.705) 14(1.905,2.705) 15(3.175,-2.705) 16(3.175,2.705) 17(4.445,-2.705) 18(4.445,2.705) 19(5.715,-2.705) 20(5.715,2.705)
CON_19X1_10029449-001RLF_S_R_S
  rect 0.33x1.956 smd: 1(4.813,4.884) 2(4.313,4.884) 3(3.813,4.884) 4(3.313,4.884) 5(2.813,4.884) 6(2.313,4.884) 7(1.813,4.884) 8(1.313,4.884) 9(0.813,4.884) 10(0.314,4.884) 11(-0.186,4.884) 12(-0.686,4.884) 13(-1.186,4.884) 14(-1.686,4.884) 15(-2.186,4.884) 16(-2.686,4.884) 17(-3.186,4.884) 18(-3.686,4.884) 19(-4.186,4.884)
  round 2.007 hole 1.321: 20(7.313,3.884) 21(-7.186,3.884) 22(7.913,-1.016) 23(-7.786,-1.016)
CON_AV4_SJ-3524-SMT-1_R_S
  round 1.549 hole 1.676 unplated: (-2.411,0.008) (4.589,0.008)
  rect 2.21x2.794 smd: 1(-3.511,-3.692) 3(-1.511,3.708)
  rect 2.794x2.794 smd: 2(5.889,-3.692) 4(9.789,0.762)
CON_DB9_182-009-113R531_P_R_T
  rect 1.753x1.753 hole 1.118: 1(0,0)
  round 1.753 hole 1.118: 2(2.769,0) 3(5.537,0) 4(8.306,0) 5(11.074,0) 6(1.384,-2.845) 7(4.153,-2.845) 8(6.921,-2.845) 9(9.69,-2.845)
  round 4.064 hole 3.048: 10(18.034,-1.422) 11(-6.96,-1.422)
