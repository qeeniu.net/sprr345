# Allegro board PROC046_REVA_BOARD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_DQ12: length 63.9
  TOP w0.102: U39.E3 139.92,164.54 139.92,164.44 141.35,163.01 144.14,163.01 144.7,162.45 v1(147.57,162.45)
  TOP w0.127: U1.Y7 v1(168.41,123.41)
  L03_SIG1 w0.102: v1(147.57,162.45) 151.52,158.5 151.66,158.5 152,158.84 152.15,158.84 152.29,158.7 152.29,158.55 151.95,158.21 151.95,158.07 152.1,157.93 152.24,157.93 152.58,158.27 152.72,158.27 152.87,158.12 152.87,157.98 152.53,157.64 152.53,157.5 152.67,157.35 152.81,157.35 153.15,157.69 153.3,157.69 153.44,157.55 153.44,157.4 153.1,157.06 153.1,156.92 154.66,155.36 154.66,139.85 155.76,138.76 156.67,138.76 158.53,136.9 160.08,136.9 162.84,134.14 162.84,129.02 163.32,128.54 165.07,128.54 165.63,127.99 165.63,127.26 165.87,127.01 166.32,127.01 166.39,126.94 166.39,126.26 166.45,126.2 167.41,126.2 168,125.62 168,123.83 v1(168.41,123.41)
DDR_DQ13: length 63.9
  TOP w0.102: U39.E8 140.08,160.38 140.08,159.3 140.74,158.64 143.56,158.64 143.99,159.07 144.91,159.07 145.36,158.62 145.37,158.62 v1(145.66,158.33)
  TOP w0.127: U1.AB6 v1(166.81,125.01)
  L03_SIG1 w0.102: v1(166.81,125.01) 166.64,125.01 166.22,125.44 164.9,125.44 163.96,126.38 162.03,126.38 161.7,126.71 161.05,126.71 160.52,127.24 160.52,128.15 158.14,130.52 156.01,130.52 154.86,131.66 154.86,133.76 153.87,134.75 153.87,137.38 152.37,138.88 152.37,151.6 148.89,155.09 148.75,155.09 148.4,154.73 148.23,154.73 148.08,154.88 148.08,155 148.46,155.37 148.46,155.52 148.32,155.66 148.17,155.66 147.49,154.98 147.35,154.98 147.2,155.12 147.2,155.27 147.89,155.95 147.89,156.09 147.74,156.24 147.6,156.24 146.92,155.55 146.77,155.55 146.63,155.7 146.63,155.84 147.31,156.52 147.31,156.67 147.17,156.81 147.02,156.81 146.34,156.13 146.2,156.13 146.05,156.27 146.05,156.42 146.74,157.1 146.74,157.24 146.59,157.38 146.45,157.38 145.77,156.7 145.62,156.7 145.48,156.85 145.48,156.99 146.16,157.67 146.16,157.82 145.94,158.03 145.94,158.05 v1(145.66,158.33)
DDR_DQ14: length 63.9
  TOP w0.102: v1(144.12,168.01) 143.08,169.05 141.52,169.05 140.85,168.38 140.85,166.01 U39.D2
  TOP w0.127: U1.Y6 v1(168.41,124.21)
  L03_SIG1 w0.102: v1(144.12,168.01) 145.44,168.01 155.68,157.77 155.68,140.27 156.2,139.75 157.04,139.75 158.83,137.96 160.45,137.96 163.98,134.43 163.98,131.16 167.22,127.92 167.22,127.1 168.61,125.71 168.61,125.43 168.78,125.26 168.78,125.24 168.79,125.24 168.79,124.58 168.42,124.21 v1(168.41,124.21)
DDR_DQ15: length 64
  TOP w0.102: v1(147.21,161.55) 146.92,161.84 146.82,161.84 146.82,161.84 144.55,161.84 143.87,162.52 140.18,162.52 139.65,161.99 U39.E7
  TOP w0.127: U1.AC4 v1(165.21,126.61)
  L03_SIG1 w0.102: v1(165.21,126.61) 164.72,127.1 164.72,127.62 164.11,128.23 163.07,128.23 162.18,129.12 162.18,134.08 159.87,136.39 156.57,136.39 155.5,137.45 155.5,138.3 154.15,139.64 154.15,154.61 153.59,155.17 153.5,155.17 153.29,154.96 153.14,154.96 153,155.1 153,155.24 153.16,155.41 153.16,155.6 153.02,155.75 152.88,155.75 152.51,155.38 152.37,155.38 152.22,155.52 152.22,155.67 152.59,156.03 152.59,156.18 152.45,156.32 152.3,156.32 151.93,155.95 151.79,155.95 151.65,156.1 151.65,156.24 152.01,156.61 152.01,156.75 151.87,156.89 151.73,156.89 151.36,156.53 151.22,156.53 151.07,156.67 151.07,156.81 151.44,157.18 151.44,157.33 151.3,157.47 151.15,157.47 150.78,157.1 150.64,157.1 150.5,157.25 150.5,157.39 150.86,157.76 150.86,157.9 150.72,158.04 150.58,158.04 150.21,157.68 150.07,157.68 149.92,157.82 149.92,157.96 150.29,158.33 150.29,158.48 150.15,158.62 150,158.62 149.64,158.25 149.49,158.25 149.35,158.4 149.35,158.54 149.72,158.91 149.72,159.05 149.45,159.32 149.3,159.32 149.01,159.02 148.86,159.02 148.72,159.17 148.72,159.31 149.01,159.61 149.01,159.75 148.87,159.89 148.73,159.89 148.43,159.6 148.29,159.6 148.15,159.74 148.15,159.89 148.44,160.18 148.44,160.33 v1(147.21,161.55)
DDR_DQ16: length 56.9
  TOP w0.102: v1(147.16,149.82) 146.66,149.82 145.9,149.06 142.56,149.06 U45.B3
  TOP w0.127: U1.AC6 v1(166.01,125.01)
  L08_SIG2 w0.102: v1(166.01,125.01) 165.28,125.74 164.54,125.74 163.68,126.61 161.57,126.61 161.34,126.84 160.96,126.84 159.59,128.21 156.44,128.21 154.27,130.38 153.96,130.38 152.8,131.54 152.8,133.49 152.73,133.55 152.73,134.3 152.8,134.36 152.8,150.34 152.1,151.04 151.73,151.04 151.63,151.14 151.63,151.75 151.53,151.86 151.33,151.86 151.22,151.75 151.22,151.14 151.12,151.04 150.89,151.04 150.79,151.14 150.79,152.41 150.69,152.52 150.49,152.52 150.39,152.41 150.39,151.14 150.28,151.04 150.08,151.04 149.98,151.14 149.98,152.41 149.88,152.52 149.67,152.52 149.57,152.41 149.57,151.14 149.47,151.04 149.27,151.04 149.17,151.14 149.17,152.41 149.07,152.52 148.86,152.52 148.76,152.41 148.76,151.14 148.66,151.04 148.38,151.04 v1(147.16,149.82)
DDR_DQ17: length 56.8
  TOP w0.102: U45.C7 v1(141.65,145.97)
  TOP w0.127: U1.AA8 v1(167.61,123.41)
  L08_SIG2 w0.102: v1(141.65,145.97) 141.94,145.68 141.94,142.59 145.36,139.16 145.36,133.88 145.26,133.78 143.94,133.78 143.84,133.68 143.84,133.48 143.94,133.37 145.26,133.37 145.36,133.27 145.36,133.07 145.26,132.97 143.94,132.97 143.84,132.87 143.84,132.66 143.94,132.56 145.26,132.56 145.36,132.46 145.36,132.26 145.26,132.16 143.94,132.16 143.84,132.05 143.84,131.85 143.94,131.75 145.26,131.75 146.13,130.89 146.13,129.76 147.32,128.56 147.32,125.36 151.03,121.66 159.72,121.66 160.55,122.49 164.19,122.49 164.87,121.81 165.3,121.81 165.71,121.4 167.08,121.4 167.21,121.53 U1.AA8 v1(167.61,123.41)
DDR_DQ18: length 57
  TOP w0.102: v1(143.89,149.62) 143.51,150 141.62,150 U45.C2
  TOP w0.127: U1.AA7 v1(166.81,124.21)
  L08_SIG2 w0.102: v1(166.81,124.21) 166.81,124.2 166.39,123.78 166.39,123.26 166.17,123.03 161.82,123.03 161.55,123.3 159,123.3 158.83,123.13 154.37,123.13 154.32,123.18 153.76,123.18 153.23,123.71 150.92,123.71 148.72,125.91 148.72,133.95 148.47,134.2 148.32,134.2 147.95,133.83 147.81,133.83 147.66,133.97 147.66,134.11 148.04,134.49 148.04,134.63 147.12,135.55 147.12,135.85 147.02,135.95 146.84,135.95 146.74,136.05 146.74,136.25 146.84,136.35 147.02,136.35 147.12,136.46 147.12,136.66 147.02,136.76 146.84,136.76 146.74,136.86 146.74,137.07 146.84,137.17 147.02,137.17 147.12,137.27 147.12,137.47 147.02,137.57 146.84,137.57 146.74,137.67 146.74,137.88 146.84,137.98 147.02,137.98 147.12,138.08 147.12,139.49 143.89,142.71 143.89,145.8 143.79,145.9 143.28,145.9 143.18,146 143.18,146.21 143.28,146.31 143.79,146.31 143.89,146.41 143.89,146.61 143.79,146.71 143.28,146.71 143.18,146.82 143.18,147.02 143.28,147.12 143.79,147.12 143.89,147.22 143.89,147.42 143.79,147.53 143.28,147.53 143.18,147.63 143.18,147.83 143.28,147.93 143.79,147.93 143.89,148.03 143.89,148.24 143.79,148.34 143.28,148.34 143.18,148.44 143.18,148.64 143.28,148.75 143.79,148.75 143.89,148.85 v1(143.89,149.62)
DDR_DQ19: length 57
  TOP w0.102: U45.C8 141.6,145.21 141.6,144.29 141.94,143.96 143.66,143.96 144.04,144.34 145.64,144.34 145.8,144.19 v1(146.2,144.19)
  TOP w0.127: U1.AD7 164.41,124.21 v1(163.32,124.21)
  L08_SIG2 w0.102: v1(163.32,124.21) 162.63,124.91 161.59,124.91 161.32,124.64 160.43,124.64 160.08,124.98 155.58,124.98 155.42,124.98 153.86,126.54 153.86,127.84 153.39,128.31 152.64,128.31 152.54,128.41 152.54,128.74 152.44,128.84 152.24,128.84 152.13,128.74 152.13,128.41 152.03,128.31 151.66,128.31 150.29,129.68 150.29,134.76 149.78,135.27 149.78,135.99 149.68,136.09 149.33,136.09 149.22,136.19 149.22,136.39 149.33,136.49 149.68,136.49 149.78,136.6 149.78,136.8 149.68,136.9 149.33,136.9 149.22,137 149.22,137.21 149.33,137.31 149.68,137.31 149.78,137.41 149.78,137.61 149.68,137.71 149.33,137.71 149.22,137.82 149.22,138.02 149.33,138.12 149.68,138.12 149.78,138.22 149.78,138.42 150.29,138.93 150.29,140.79 150.19,140.89 149.99,140.89 149.89,140.99 149.89,141.19 149.99,141.29 150.19,141.29 150.29,141.4 150.29,141.6 150.19,141.7 149.99,141.7 149.89,141.8 149.89,142 149.99,142.11 150.19,142.11 150.29,142.21 150.29,142.41 150.19,142.51 149.99,142.51 149.89,142.61 149.89,142.82 149.99,142.92 150.19,142.92 150.29,143.02 150.29,143.22 150.19,143.33 149.99,143.33 149.89,143.43 149.89,143.63 149.99,143.73 150.19,143.73 150.29,143.83 150.29,144.53 149.82,145.01 149.5,145.01 149.43,144.93 149.43,144.58 149.53,144.48 149.81,144.48 149.91,144.37 149.91,144.17 149.81,144.07 149.53,144.07 149.43,143.97 149.43,143.24 149.3,143.11 149.13,143.11 148.99,143.25 148.99,144.93 148.9,145.02 148.68,145.02 148.59,144.93 148.59,144.03 148.49,143.92 148.28,143.92 148.21,144 148.21,144.96 148.14,145.02 147.92,145.02 147.8,144.9 147.8,144.2 147.7,144.1 147.5,144.1 147.39,144.2 147.39,144.37 147.29,144.47 146.49,144.47 v1(146.2,144.19)
DDR_DQ20: length 57
  TOP w0.102: v1(147.57,147.21) 144.7,147.21 144.14,147.77 141.35,147.77 139.92,149.2 139.92,149.3 U45.E3
  TOP w0.127: U1.AC7 v1(165.21,124.21)
  L08_SIG2 w0.102: v1(147.57,147.21) 147.57,147.85 147.47,147.95 147.14,147.95 147.04,148.06 147.04,148.26 147.14,148.36 147.47,148.36 147.57,148.46 147.57,149.19 148.72,150.33 149.61,150.33 149.72,150.23 149.72,149.77 149.82,149.67 150.02,149.67 150.12,149.77 150.12,150.23 150.22,150.33 150.43,150.33 150.53,150.23 150.53,149.77 150.63,149.67 150.83,149.67 150.94,149.77 150.94,150.23 151.04,150.33 151.76,150.33 151.99,150.1 151.99,149.01 151.89,148.91 151.41,148.91 151.31,148.81 151.31,148.6 151.41,148.5 151.89,148.5 151.99,148.4 151.99,138.57 151.16,137.73 151.16,135.81 151.61,135.35 151.61,134.86 151.99,134.48 151.99,131.74 152.1,131.64 152.1,131.51 153.7,129.91 154.13,129.91 155.63,128.41 155.63,127.21 156.02,126.81 158.45,126.81 158.97,126.29 163.44,126.29 163.88,125.85 163.88,125.54 v1(165.21,124.21)
DDR_DQ21: length 56.6
  TOP w0.102: U1.AE7 163.14,123.81 v1(162.74,124.21) ; v1(145.52,143.22) 145.23,143.51 145.23,143.69 145.09,143.83 143.99,143.83 143.68,143.52 140.73,143.52 140.08,144.16 140.08,145.14 U45.E8
  L08_SIG2 w0.102: v1(162.74,124.21) 162.36,124.59 161.71,124.59 161.35,124.23 158.04,124.23 157.88,124.07 155.42,124.07 152.83,126.66 150.37,126.66 149.76,127.27 149.76,134.61 148.82,135.55 148.82,138.96 148.92,139.06 149.65,139.06 149.75,139.16 149.75,139.36 149.65,139.46 148.92,139.46 148.82,139.57 148.82,139.77 148.92,139.87 149.65,139.87 149.75,139.97 149.75,140.18 149.65,140.28 148.92,140.28 148.82,140.38 148.82,140.83 148.59,141.06 148.59,141.2 149.38,142 149.38,142.14 149.24,142.28 149.1,142.28 147.95,141.14 147.8,141.14 147.66,141.28 147.66,141.42 148.81,142.57 148.81,142.72 148.66,142.86 148.55,142.86 147.25,141.56 147.1,141.56 146.96,141.7 146.96,141.85 148.23,143.12 148.23,143.29 148.09,143.43 147.95,143.43 147.75,143.23 147.65,143.23 147.21,143.68 147.04,143.68 146.91,143.55 146.91,143.4 147.31,143 147.31,142.8 147.15,142.64 147.01,142.64 146.14,143.51 145.8,143.51 v1(145.52,143.22)
DDR_DQ22: length 57.1
  TOP w0.102: U1.AB8 v1(166.81,123.41) ; v1(143.87,152.82) 141.96,152.82 140.85,151.71 140.85,150.77 U45.D2
  L08_SIG2 w0.102: v1(143.87,152.82) 143.87,151.45 142.85,150.43 142.85,142.56 145.77,139.64 145.77,131.82 147.73,129.86 147.73,125.77 151.41,122.09 157.5,122.09 157.67,122.26 159.39,122.26 160.02,122.89 161.38,122.89 161.45,122.83 164.45,122.83 165.05,122.23 166.17,122.23 166.39,122.46 166.39,122.92 166.81,123.34 v1(166.81,123.41)
DDR_DQ23: length 56.8
  TOP w0.102: v1(147.21,146.31) 146.92,146.6 146.82,146.6 146.82,146.6 144.55,146.6 143.87,147.28 140.18,147.28 139.65,146.75 U45.E7
  TOP w0.127: U1.AB7 v1(166.01,124.21)
  L08_SIG2 w0.102: v1(147.21,146.31) 147.52,146.62 147.82,146.62 148.16,146.97 148.16,147.49 148.67,148 148.67,149.06 148.77,149.16 148.97,149.16 149.1,149.04 149.1,147.87 149.2,147.77 149.4,147.77 149.5,147.87 149.5,149.09 149.58,149.16 149.78,149.16 149.89,149.06 149.89,148 149.99,147.89 150.19,147.89 150.29,148 150.29,149.06 150.39,149.16 150.6,149.16 150.7,149.06 150.7,148 150.8,147.89 151.41,147.89 151.49,147.82 151.49,138.67 150.75,137.94 150.75,135.64 151.21,135.18 151.21,131.79 155.12,127.88 155.12,127.1 155.3,126.92 155.3,126.91 155.88,126.33 158.24,126.33 158.75,125.82 160.86,125.82 161.29,125.39 163.47,125.39 165.07,123.79 165.58,123.79 166.01,124.21 v1(166.01,124.21)
DDR_DQ24: length 45.2
  TOP w0.102: v1(147.16,134.58) 146.66,134.58 145.9,133.82 142.56,133.82 U49.B3
  TOP w0.127: U1.Y8 v1(167.61,122.61)
  L03_SIG1 w0.102: v1(147.16,134.58) 147.88,134.58 147.98,134.68 147.98,135.08 147.88,135.18 146.02,135.18 145.92,135.28 145.92,135.49 146.02,135.59 147.88,135.59 147.98,135.69 147.98,135.89 147.88,135.99 146.02,135.99 145.92,136.1 145.92,136.3 146.02,136.4 147.36,136.4 147.98,137.02 148.18,137.02 148.28,136.92 148.28,134.78 148.49,134.58 149.2,134.58 149.58,134.2 149.58,133.15 153.39,129.34 153.39,129.07 155.69,126.78 156.37,126.78 156.62,126.53 156.62,125.62 156.82,125.41 157.63,125.41 157.84,125.21 159.48,125.21 160.01,124.68 161.38,124.68 161.56,124.86 163.83,124.86 164.62,124.06 164.76,124.06 165.51,123.31 165.53,123.31 165.84,123 167.11,123 167.49,122.61 v1(167.61,122.61)
DDR_DQ25: length 44.9
  TOP w0.102: v1(162.05,121.01) 162.34,121.3 162.34,121.31 162.45,121.41 U1.AE10 ; U49.C7 v1(141.65,130.73)
  L03_SIG1 w0.102: v1(162.05,121.01) 161.33,120.28 158.15,120.28 157.89,120.03 151.43,120.03 149.18,122.27 147.44,122.27 142.04,127.68 142.04,130.22 142.29,130.47 143.15,130.47 143.43,130.75 143.43,131.07 143.33,131.17 142.06,131.17 141.96,131.27 141.96,131.47 142.06,131.57 143.33,131.57 143.43,131.68 143.43,131.88 143.33,131.98 142.06,131.98 141.96,132.08 141.96,132.29 142.06,132.39 143.33,132.39 143.43,132.49 143.43,133.7 143.23,133.9 142.88,133.9 142.65,133.67 142.65,133.14 142.54,133.03 142.34,133.03 142.24,133.14 142.24,133.67 142.14,133.77 141.91,133.77 141.6,133.47 141.6,131.18 141.65,131.14 v1(141.65,130.73)
DDR_DQ26: length 44.9
  TOP w0.102: v1(143.89,134.38) 143.51,134.76 141.62,134.76 U49.C2
  TOP w0.127: U1.AD10 164.41,121.81 v1(163.32,121.81)
  L03_SIG1 w0.102: v1(163.32,121.81) 163.83,121.31 163.83,120.98 163.39,120.54 162.23,120.54 161.39,119.7 158.62,119.7 158.42,119.5 158.42,119.22 158.14,118.94 157.74,118.94 157.18,119.5 151.38,119.5 149.01,121.87 147.13,121.87 141.6,127.39 141.6,129.71 141.22,130.09 141.22,133.49 142.16,134.43 142.16,135.96 142.14,135.98 142.14,136.24 142.24,136.34 142.44,136.34 142.54,136.24 142.54,135.37 143.25,134.67 143.6,134.67 v1(143.89,134.38)
DDR_DQ27: length 45.2
  TOP w0.102: U49.C8 141.6,129.97 141.6,129.05 141.94,128.72 143.66,128.72 144.04,129.1 145.57,129.1 145.74,128.93 145.74,128.56 145.76,128.56 146.1,128.22 146.1,127.62 146.2,127.52 146.74,127.52 146.84,127.62 146.84,127.9 146.2,128.54 v1(146.2,128.95)
  TOP w0.127: U1.AC10 v1(166.01,121.81)
  L03_SIG1 w0.102: v1(166.01,121.81) 164.72,121.81 163.91,122.62 160.92,122.62 160.51,123.03 158.25,123.03 158.1,123.18 155.13,123.18 154.47,123.84 150.88,123.84 150.58,124.14 150.58,124.87 150.47,124.99 150.47,125.13 150.79,125.46 150.79,125.6 150.65,125.74 150.51,125.74 150.18,125.42 150.04,125.42 149.87,125.58 149.87,125.67 150.24,126.04 150.24,126.2 150.11,126.34 149.96,126.34 149.64,126.01 149.44,126.01 149.28,126.17 149.28,126.31 149.79,126.83 149.79,126.97 149.65,127.12 149.51,127.12 148.99,126.6 148.85,126.6 148.71,126.75 148.71,126.89 149.22,127.4 149.22,127.55 149.08,127.69 148.93,127.69 148.42,127.18 148.28,127.18 148.13,127.32 148.13,127.46 148.64,127.98 148.64,128.12 148.5,128.26 148.36,128.26 147.84,127.75 147.7,127.75 147.56,127.9 147.56,128.04 147.67,128.15 147.67,128.29 146.99,128.98 146.84,128.98 146.7,128.83 146.7,128.69 147.09,128.3 147.09,128.16 146.92,127.99 146.78,127.99 146.28,128.49 145.83,128.49 145.76,128.56 145.49,128.56 145.26,128.79 145.26,129.15 145.36,129.25 145.9,129.25 v1(146.2,128.95)
DDR_DQ28: length 45
  TOP w0.102: U49.E3 139.92,134.06 139.92,133.96 141.35,132.53 144.14,132.53 144.7,131.97 v1(147.57,131.97)
  TOP w0.127: U1.AB9 v1(166.01,122.61)
  L03_SIG1 w0.102: v1(166.01,122.61) 165.85,122.77 165.66,122.77 165.38,123.05 164.95,123.05 164.27,123.73 164.27,124.08 163.73,124.63 161.7,124.63 161.32,124.25 161.02,124.25 158.76,124.25 158.2,124.81 157.59,124.81 157.39,125.01 155.78,125.01 155.16,125.62 155.16,125.77 155.44,126.04 155.44,126.18 155.31,126.3 155.13,126.3 154.88,126.05 154.73,126.05 154.59,126.2 154.59,126.34 154.99,126.74 154.99,126.89 154.85,127.03 154.71,127.03 154.3,126.63 154.16,126.63 153.92,126.86 153.92,127.01 154.28,127.37 154.28,127.51 154.14,127.65 154,127.65 153.64,127.29 153.49,127.29 153.35,127.44 153.35,127.58 153.46,127.69 153.46,127.83 153.31,127.98 153.17,127.98 153.06,127.87 152.92,127.87 152.77,128.01 152.77,128.16 152.78,128.16 152.78,128.59 151.2,130.17 150.77,130.17 150.76,130.17 150.62,130.17 150.48,130.31 150.48,130.46 150.48,130.46 150.48,130.6 150.34,130.75 150.19,130.75 150.19,130.74 150.04,130.74 149.9,130.89 149.9,131.03 149.91,131.04 149.91,131.18 149.76,131.32 149.62,131.32 149.61,131.32 149.47,131.32 148.97,131.82 148.97,132.26 148.87,132.36 147.95,132.36 147.85,132.47 147.85,132.67 147.95,132.77 148.87,132.77 148.97,132.87 148.97,133.82 148.87,133.92 148.2,133.92 148.12,133.85 148.12,133.26 148.02,133.16 147.82,133.16 147.72,133.26 147.72,133.8 147.59,133.92 147.35,133.92 147.07,133.64 147.07,132.07 147.17,131.97 v1(147.57,131.97)
DDR_DQ29: length 45
  TOP w0.102: U49.E8 140.08,129.9 140.08,128.92 140.73,128.28 143.68,128.28 143.99,128.59 145.09,128.59 145.23,128.45 145.23,128.27 v1(145.52,127.98)
  TOP w0.127: U1.AB10 v1(166.81,121.81)
  L03_SIG1 w0.102: v1(145.52,127.98) 145.44,128.06 145.24,128.06 145.16,128.13 144.98,128.13 144.86,128.01 144.86,127.73 145.26,127.32 145.54,127.32 145.83,127.61 145.83,127.6 145.93,127.7 146.19,127.7 146.26,127.62 146.26,126.85 146.36,126.74 146.76,126.74 147.3,127.29 147.45,127.29 147.59,127.14 147.59,126.97 146.9,126.28 146.9,126.14 147.04,125.99 147.18,125.99 147.9,126.71 148.02,126.71 148.17,126.57 148.17,126.45 147.47,125.76 147.47,125.62 147.62,125.47 147.76,125.47 148.43,126.14 148.6,126.14 148.74,125.99 148.74,125.88 147.94,125.08 147.94,124.94 148.09,124.79 148.23,124.79 149,125.56 149.17,125.56 149.32,125.42 149.32,125.28 148.62,124.58 148.62,124.47 148.8,124.29 148.91,124.29 149.6,124.99 149.75,124.99 150.17,124.56 150.17,123.96 150.7,123.43 153.68,123.43 154.9,122.21 157.97,122.21 158.38,122.62 160.34,122.62 160.75,122.21 161.87,122.21 162.08,122.42 163.7,122.42 164.67,121.45 165.83,121.45 165.86,121.43 166.42,121.43 v1(166.81,121.81)
DDR_DQ30: length 45.3
  TOP w0.102: U1.AA10 v1(167.61,121.01)
  TOP w0.127: v1(143.64,137.56) 143.46,137.73 141.33,137.73 140.85,137.26 140.85,135.53 U49.D2
  L03_SIG1 w0.102: v1(143.64,137.56) 143.64,136.44 144.35,135.73 144.35,133.95 143.79,133.39 143.79,126.66 147.5,122.95 149.17,122.95 151.59,120.54 157.68,120.54 157.94,120.79 161.3,120.79 161.89,121.39 162.32,121.39 162.33,121.38 163.17,122.21 163.5,122.21 163.91,121.81 163.91,121.64 164.91,120.63 167.23,120.63 v1(167.61,121.01)
DDR_DQ31: length 44.9
  TOP w0.102: U49.E7 139.65,131.79 140.11,132.25 143.66,132.25 144.55,131.36 146.91,131.36 147.02,131.46 147.26,131.46 147.33,131.38 149.43,131.38 149.86,130.95 149.86,130.49 149.76,130.39 149.23,130.39 148.55,131.07 v1(147.21,131.07)
  TOP w0.127: U1.AC9 v1(165.21,122.61)
  L03_SIG1 w0.102: v1(165.21,122.61) 164.8,122.61 164.38,123.03 161.84,123.03 161.04,123.84 160.85,123.84 158.59,123.84 158.44,123.99 155.83,123.99 154.22,125.61 153.95,125.61 153.67,125.89 153.67,126.03 153.76,126.12 153.76,126.27 153.6,126.43 153.45,126.43 153.23,126.2 153.08,126.2 152.82,126.47 152.65,126.47 151.79,127.33 151.79,127.55 152.35,128.11 152.35,128.26 152.21,128.4 152.07,128.4 151.53,127.86 151.26,127.86 151.11,128 151.11,128.15 151.42,128.46 151.42,128.6 151.28,128.75 151.14,128.75 150.83,128.44 150.68,128.44 150.54,128.58 150.54,128.72 150.85,129.03 150.85,129.18 150.7,129.32 150.56,129.32 150.25,129.01 150.11,129.01 149.96,129.15 149.96,129.3 150.27,129.61 150.27,129.75 150.13,129.89 149.99,129.89 149.68,129.58 149.53,129.58 149.39,129.73 149.39,129.87 149.7,130.18 149.7,130.33 149.56,130.47 149.41,130.47 149.1,130.16 148.96,130.16 148.81,130.3 148.81,130.45 149.12,130.76 149.12,130.9 148.46,131.56 147.99,131.56 147.82,131.38 147.52,131.38 v1(147.21,131.07)
DDR_DQS0: length 75.9
  TOP w0.102: v1(146.56,179.35) 146.24,179.03 141.6,179.03 141.05,179.58 141.05,179.85 U27.C3 ; U1.AD1 164.43,128.23 162.58,128.23 162.21,128.6 161.85,128.6 v1(161.47,128.22)
  L08_SIG2 w0.102: v1(161.47,128.22) 161.47,128.43 159.92,129.97 158.34,129.97 157.55,130.76 156.4,130.76 155.41,131.76 155.41,133.28 154.87,133.82 154.87,138.17 154.27,138.77 154.27,162.16 144.11,172.32 144.11,174.13 144.36,174.39 144.64,174.39 144.77,174.51 144.77,174.75 144.64,174.88 144.36,174.88 144.11,175.14 144.11,175.73 144.44,176.06 145.71,176.06 145.83,176.19 145.83,176.43 145.71,176.56 144.49,176.56 144.11,176.94 144.11,178.51 144.57,178.97 146.18,178.97 v1(146.56,179.35)
DDR_DQS0#: length 75.9
  TOP w0.102: U27.D3 140.72,179.78 140.72,179.44 141.46,178.7 146.23,178.7 v1(146.56,178.37) ; v1(162.05,128.22) 162.37,127.9 163.92,127.9 U1.AE2
  L08_SIG2 w0.102: v1(162.05,128.22) 160.03,130.24 158.45,130.24 157.66,131.03 156.51,131.03 155.68,131.87 155.68,133.39 155.13,133.93 155.13,138.28 154.53,138.88 154.53,162.27 144.37,172.43 144.37,174.02 144.48,174.12 144.75,174.12 145.03,174.4 145.03,174.86 144.75,175.15 144.48,175.15 144.37,175.25 144.37,175.62 144.55,175.8 145.82,175.8 146.1,176.08 146.1,176.54 145.82,176.82 144.6,176.82 144.37,177.05 144.37,178.4 144.68,178.7 144.9,178.7 145.01,178.6 145.01,177.97 145.11,177.87 145.31,177.87 145.41,177.96 145.41,178.6 145.51,178.7 146.22,178.7 v1(146.56,178.37)
DDR_DQS1: length 63.8
  TOP w0.102: v1(146.56,164.11) 146.24,163.79 141.74,163.79 141.05,164.48 141.05,164.61 U39.C3 ; U1.AD4 164.43,126.6 162.25,126.6 v1(161.47,125.81)
  L03_SIG1 w0.102: v1(146.56,164.11) 146.18,163.73 145.11,163.73 144.72,163.34 144.72,156.34 148.91,152.15 149.27,152.15 149.73,152.62 149.91,152.62 150.08,152.45 150.08,152.27 149.62,151.81 149.62,151.44 149.92,151.14 150.28,151.14 150.75,151.61 150.93,151.61 151.1,151.44 151.1,151.26 150.63,150.79 150.63,150.43 151.17,149.89 151.17,133.83 151.81,133.2 152.17,133.2 152.41,133.43 152.59,133.43 152.76,133.26 152.76,133.09 152.52,132.85 152.52,132.48 153.26,131.76 156.34,128.68 157.16,128.68 157.19,128.66 157.75,128.09 158.97,128.09 159.22,127.85 159.22,127.66 159.1,127.54 158.97,127.54 158.69,127.26 158.69,126.83 158.94,126.58 160.03,126.58 160.57,126.04 161.24,126.04 v1(161.47,125.81)
DDR_DQS1#: length 63.8
  TOP w0.102: v1(162.05,125.81) 162.05,125.93 162.39,126.27 163.96,126.27 U1.AE4 ; U39.D3 140.72,164.54 140.72,164.34 141.6,163.46 146.23,163.46 v1(146.56,163.13)
  L03_SIG1 w0.102: v1(162.05,125.81) 161.56,126.3 160.68,126.3 160.14,126.85 159.05,126.85 158.96,126.94 158.96,127.15 159.08,127.27 159.21,127.27 159.49,127.55 159.49,127.96 159.08,128.36 157.86,128.36 157.45,128.77 157.27,128.95 156.45,128.95 153.44,131.95 152.79,132.6 152.79,132.74 153.02,132.97 153.02,133.38 152.7,133.7 152.3,133.7 152.06,133.46 151.92,133.46 151.44,133.94 151.44,150 150.9,150.54 150.9,150.68 151.36,151.15 151.36,151.55 151.04,151.87 150.64,151.87 150.17,151.41 150.03,151.41 149.89,151.55 149.89,151.7 150.35,152.16 150.35,152.56 150.02,152.89 149.62,152.89 149.16,152.42 149.02,152.42 144.98,156.45 144.98,163.23 145.22,163.46 146.35,163.46 146.51,163.62 146.94,163.62 147,163.55 147,163.2 146.93,163.13 v1(146.56,163.13)
DDR_DQS2: length 57
  TOP w0.102: U1.AE6 163.94,124.68 162.64,124.68 162.34,124.38 162.34,124 v1(161.9,123.56) ; U45.C3 141.05,149.37 141.05,149.24 141.74,148.55 146.24,148.55 v1(146.56,148.87)
  L08_SIG2 w0.102: v1(146.56,148.87) 146.22,148.53 146.08,148.53 146,148.61 146,148.86 145.9,148.96 145.67,148.96 145.59,148.88 145.59,148.63 144.32,147.36 144.32,146.88 144.58,146.62 145.54,146.62 145.64,146.52 145.64,146.32 145.54,146.21 144.63,146.21 144.32,145.91 144.32,145.45 144.6,145.16 145.31,145.16 145.41,145.06 145.41,144.86 145.31,144.76 144.6,144.76 144.32,144.47 144.32,142.78 145.28,141.83 145.68,141.83 145.8,141.95 145.94,141.95 146.09,141.8 146.09,141.66 145.96,141.54 145.96,141.14 146.29,140.81 146.69,140.81 146.81,140.94 146.96,140.94 147.1,140.79 147.1,140.65 146.98,140.53 146.98,140.12 148.16,138.94 148.16,138.32 148.06,138.22 147.72,138.22 147.44,137.94 147.44,137.48 147.72,137.2 148.06,137.2 148.16,137.1 148.16,136.89 148.06,136.79 147.72,136.79 147.44,136.51 147.44,136.05 147.72,135.76 148.06,135.76 148.16,135.66 148.16,135.21 149.14,134.23 149.14,126.84 149.14,126.33 150.49,124.98 152.96,124.98 154.5,123.44 158.28,123.44 158.45,123.61 161.85,123.61 v1(161.9,123.56)
DDR_DQS2#: length 57
  TOP w0.102: U1.AD6 164.41,125.01 162.5,125.01 161.9,124.41 v1(161.9,124.21) ; U45.D3 140.72,149.3 140.72,149.1 141.6,148.22 146.23,148.22 v1(146.56,147.89)
  L08_SIG2 w0.102: v1(161.9,124.21) 161.56,123.88 158.34,123.88 158.17,123.71 154.61,123.71 153.07,125.24 150.6,125.24 149.41,126.44 149.41,126.73 149.41,134.34 148.43,135.32 148.43,135.77 148.17,136.03 147.84,136.03 147.71,136.16 147.71,136.4 147.84,136.52 148.17,136.52 148.43,136.78 148.43,137.21 148.17,137.46 147.84,137.46 147.71,137.59 147.71,137.83 147.84,137.96 148.17,137.96 148.43,138.21 148.43,139.05 147.24,140.24 147.24,140.41 147.37,140.54 147.37,140.9 147.07,141.2 146.7,141.2 146.58,141.08 146.4,141.08 146.23,141.25 146.23,141.43 146.35,141.55 146.35,141.92 146.05,142.22 145.69,142.22 145.57,142.09 145.39,142.09 144.58,142.89 144.58,144.36 144.71,144.49 145.42,144.49 145.68,144.75 145.68,145.17 145.42,145.43 144.71,145.43 144.58,145.56 144.58,145.8 144.74,145.95 145.65,145.95 145.91,146.21 145.91,146.63 145.65,146.89 144.69,146.89 144.58,146.99 144.58,147.24 145.66,148.32 145.9,148.32 145.96,148.26 146.3,148.26 146.56,148.01 v1(146.56,147.89)
DDR_DQS3: length 45.3
  TOP w0.102: U1.AE9 163.95,122.27 162.51,122.27 v1(162.05,121.81) ; U49.C3 141.05,134.13 141.05,134 141.74,133.31 146.24,133.31 v1(146.56,133.63)
  L03_SIG1 w0.102: v1(162.05,121.81) 161.83,121.59 161.81,121.59 161.49,121.27 161.32,121.27 161.21,121.17 157.89,121.17 157.47,121.59 151.27,121.59 149.53,123.33 149.4,123.33 148.88,123.33 148.16,124.05 147.99,124.05 147.62,123.68 147.23,123.68 146.89,124.01 146.89,124.41 147.29,124.8 147.29,124.92 147.15,125.07 147.06,125.07 146.69,124.7 146.23,124.7 145.95,124.98 145.95,125.41 146.28,125.74 146.28,125.93 146.14,126.08 145.99,126.08 145.63,125.72 145.21,125.72 144.2,126.74 144.2,129.5 144.76,130.06 145.76,130.06 145.86,130.16 145.86,130.37 145.79,130.44 145.49,130.44 145.19,130.75 145.19,131.16 145.47,131.44 146.29,131.44 146.42,131.57 146.42,131.77 146.32,131.88 144.99,131.88 144.68,132.18 144.68,132.93 145.04,133.29 145.27,133.29 145.37,133.39 145.37,133.67 145.47,133.77 145.67,133.77 145.77,133.67 145.77,133.39 145.87,133.29 146.22,133.29 v1(146.56,133.63)
DDR_DQS3#: length 45.3
  TOP w0.102: U1.AD9 164.42,122.6 162.26,122.6 v1(161.47,121.81) ; U49.D3 140.72,134.06 140.72,133.86 141.6,132.98 146.23,132.98 v1(146.56,132.65)
  L03_SIG1 w0.102: v1(146.56,132.65) 146.18,133.02 145.15,133.02 144.95,132.82 144.95,132.29 145.1,132.14 146.43,132.14 146.69,131.88 146.69,131.46 146.41,131.18 145.58,131.18 145.45,131.05 145.45,130.86 145.61,130.71 145.9,130.71 146.13,130.48 146.13,130.05 145.87,129.8 144.87,129.8 144.46,129.39 144.46,126.85 145.32,125.99 145.52,125.99 145.88,126.35 146.25,126.35 146.55,126.05 146.55,125.63 146.22,125.3 146.22,125.09 146.34,124.97 146.58,124.97 146.95,125.33 147.26,125.33 147.56,125.03 147.56,124.69 147.16,124.3 147.16,124.12 147.34,123.95 147.51,123.95 147.88,124.32 148.27,124.32 148.99,123.6 149.29,123.6 149.64,123.6 151.38,121.86 157.59,121.86 158,121.44 161.1,121.44 161.2,121.54 161.33,121.54 161.47,121.68 v1(161.47,121.81)
DDR_DVDD18: length 29.1
  TOP w0.254: U17.P7 v1(238.22,47.65) ; U17.P9 v1(239.82,47.65) ; U17.N9 v1(239.82,48.45) ; U17.P10 v1(241.42,47.65) ; U17.R8 v1(239.02,46.85) ; U17.P8 v1(239.02,47.65) ; U17.N6 v1(237.42,48.45) ; U17.R9 v1(239.82,46.85) ; U17.R7 v1(238.22,46.85) ; U17.N10 v1(241.42,48.45)
  L03_SIG1 w0.102: 232.77,47.61 232.21,48.17 234.47,48.17 235.13,48.83 237.03,48.83 v1(237.42,48.45) 237.02,48.05 235.79,48.05 235.36,47.61 232.77,47.61
  L03_SIG1 w0.381: v2(232.16,50.18) 232.16,48.22 232.21,48.17
  BOTTOM w0.381: v1(239.82,47.65) v1(239.02,47.65) v1(239.02,46.85) v1(238.22,46.85) v1(238.22,47.65) v1(237.42,48.45) ; v1(239.82,47.65) v1(241.42,47.65) v1(241.42,48.45) ; v1(239.82,47.65) v1(239.82,48.45) ; v1(239.82,47.65) v1(239.82,46.85) ; FB6.1 231.39,50.42 231.64,50.18 v2(232.16,50.18)
DDR_ODT: length 128.9
  TOP w0.102: U27.G1 138.31,181.91 138.31,182.18 138.7,182.56 v1(138.72,182.56) 139.04,182.88 139.04,184.57 138.68,184.93 R215.1 ; v1(138.73,152.08) 138.7,152.08 138.05,151.43 U45.G1 ; U1.AA13 v1(166.81,118.61) ; v1(138.73,121.6) 138.7,121.6 138.05,120.95 U52.G1 ; v1(138.73,136.84) 138.7,136.84 138.05,136.19 U49.G1 ; v1(138.72,167.32) 138.7,167.32 138.05,166.67 138.05,166.61 138.05,166.61 U39.G1
  L03_SIG1 w0.102: v1(138.72,182.56) 138.72,181.41 137.74,180.43 137.74,178.58 137.21,178.04 137.21,174.61 138.18,173.65 138.18,171.77 138.28,171.66 138.53,171.66 138.63,171.56 138.63,171.26 138.53,171.16 138.28,171.16 138.18,171.05 138.18,167.87 v1(138.72,167.32) 138.35,166.95 138.35,164.58 137.62,163.84 137.62,163.13 137.16,162.68 137.16,161.48 138.16,160.49 138.16,158.79 138.84,158.1 138.84,152.6 138.73,152.49 v1(138.73,152.08) 138.73,150.72 137.82,149.81 137.82,148.12 137.13,147.44 137.13,145.1 137.41,144.82 137.41,144.46 138.1,143.78 138.1,140.62 137.74,140.26 137.74,139.17 137.86,139.05 137.86,138.39 138.73,137.53 v1(138.73,136.84) 138.36,136.47 138.36,135.1 137.57,134.31 137.57,132.65 137.13,132.22 137.13,129.43 137.54,129.02 138.13,129.02 138.28,128.86 138.28,122.05 v1(138.73,121.6) 138.38,121.26 138.38,120.39 137.69,119.7 137.69,117.51 136.91,116.72 136.91,114.76 137.01,114.66 137.08,114.66 137.19,114.56 137.19,114.35 137.08,114.25 137.01,114.25 136.91,114.15 136.91,113.81 138,112.71 139.4,112.71 139.54,112.85 139.54,113.07 139.64,113.17 139.84,113.17 139.94,113.07 139.94,112.85 140.04,112.75 140.35,112.75 140.78,113.18 141.01,113.18 141.66,113.83 141.66,115.15 143.18,116.68 143.18,117.19 145.08,119.09 145.08,119.95 145.47,120.33 148.56,120.33 148.84,120.06 148.84,118.84 148.59,118.58 148.59,118.1 149,117.69 149,117.68 150.1,116.58 158.91,116.58 159.61,117.29 161.81,117.29 162.71,116.38 163.62,116.38 164.19,116.95 164.19,117.99 164.83,118.63 164.83,118.77 165.07,119.01 166.41,119.01 v1(166.81,118.61)
DDR_ODT1: length 16.1
  TOP w0.102: U1.Y12 v1(167.61,119.41) ; TP153.1 v2(154.18,118.89)
  L03_SIG1 w0.102: v1(167.61,119.41) 167.22,119.8 165.02,119.8 164.67,120.16 162.38,120.16 161.52,119.29 159.07,119.29 158.31,118.53 157.57,118.53 157.21,118.89 v2(154.18,118.89)
DDR_RAS#: length 132
  TOP w0.102: v1(139.28,148.85) 138.85,149.29 U45.F3 ; v1(139.28,179.33) 138.85,179.77 138.85,179.95 138.85,179.95 U27.F3 ; U39.F3 138.85,164.53 138.85,164.53 v1(139.28,164.09) ; v2(145.31,182.44) 145.64,182.77 R208.1 ; v1(139.28,118.37) 138.85,118.81 U52.F3 ; U49.F3 138.85,134.05 v1(139.28,133.61) ; 163.72,119.01 v1(163.32,119.41)
  TOP w0.127: U1.AE13 163.72,119.01
  L03_SIG1 w0.102: v2(145.31,182.44) 144.35,182.44 142.77,180.86 140.81,180.86 v1(139.28,179.33)
  L08_SIG2 w0.102: v1(163.32,119.41) 162.9,118.99 162.18,118.99 161.75,119.41 159.45,119.41 159.08,119.05 158.5,119.05 158.29,118.84 157.15,118.84 157.05,118.94 157.05,118.99 156.95,119.09 155.79,119.09 154.98,119.9 153.37,119.9 153.31,119.95 151.13,119.95 150.24,119.06 150.24,118.23 150.01,118 150.01,117.9 149.56,117.44 148.53,117.44 148.42,117.34 148.42,116.65 148.32,116.55 148.12,116.55 148.02,116.65 148.02,117.34 147.92,117.44 147.71,117.44 147.61,117.34 147.61,116.65 147.51,116.55 147.31,116.55 147.2,116.65 147.2,117.34 147.1,117.44 146.84,117.44 146.74,117.54 146.74,118.36 146.84,118.46 147.68,118.46 147.78,118.57 147.78,118.77 147.68,118.87 146.84,118.87 146.74,118.97 146.74,119.18 146.84,119.28 147.68,119.28 147.78,119.38 147.78,119.58 147.68,119.68 146.84,119.68 146.76,119.76 146.76,120.33 146.66,120.44 146.46,120.44 146.36,120.33 146.36,119.85 146.23,119.72 145.24,119.72 145.14,119.62 145.14,119.41 145.24,119.31 146.23,119.31 146.33,119.21 146.33,119.01 146.23,118.91 145.24,118.91 145.14,118.8 145.14,118.6 145.24,118.5 146.23,118.5 146.33,118.4 146.33,117.54 146.23,117.44 145.77,117.44 144.53,118.68 144.16,118.68 144.06,118.79 144.06,119.52 143.96,119.62 142.98,119.62 142.88,119.73 142.88,120.51 142.8,120.59 142.6,120.59 142.47,120.46 142.47,119.73 142.13,119.38 141.98,119.38 140.92,120.45 140.8,120.45 140.66,120.3 140.66,120.13 141.69,119.09 141.69,118.95 141.5,118.76 140.46,118.76 140.08,118.37 v1(139.28,118.37) 139.65,118.74 139.65,121.48 139.95,121.78 139.95,129.57 139.85,129.67 139.5,129.67 139.4,129.77 139.4,130.08 139.5,130.18 139.85,130.18 139.95,130.28 139.95,132.5 139.28,133.17 v1(139.28,133.61) 139.65,133.98 139.65,136.65 139.98,136.99 139.98,145.31 139.88,145.41 139.42,145.41 139.32,145.52 139.32,145.82 139.42,145.92 139.88,145.92 139.98,146.02 139.98,146.8 139.57,147.21 139.57,148.56 v1(139.28,148.85) 139.69,149.26 139.69,150.45 139.59,150.55 139.09,150.55 138.99,150.65 138.99,150.96 139.09,151.06 139.59,151.06 139.68,151.16 139.68,151.92 139.93,152.17 139.93,163.45 v1(139.28,164.09) 139.67,164.49 139.67,165.85 139.67,165.85 139.67,166.17 139.67,166.17 139.67,167.2 140.11,167.63 140.11,175.86 140,175.96 139.5,175.96 139.4,176.06 139.4,176.36 139.5,176.46 140,176.46 140.11,176.57 140.11,177.18 139.28,178 v1(139.28,179.33)
DDR_RESET#: length 129.9
  TOP w0.102: U1.Y18 v1(167.61,114.61) ; v1(131.44,150.28) 131.85,150.28 131.94,150.37 U45.N2 ; R443.2 146.09,109.26 147.07,109.26 v2(147.37,109.57) ; v1(131.44,135.04) 131.85,135.04 131.94,135.13 U49.N2 ; v1(131.44,180.76) 131.85,180.76 131.94,180.85 U27.N2 ; U39.N2 131.94,165.61 131.85,165.52 v1(131.44,165.52) ; U52.N2 131.94,119.89 131.85,119.8 v1(131.44,119.8)
  L03_SIG1 w0.102: v1(131.44,180.76) 131.14,180.76 129.59,179.21 129.59,167.29 131.07,165.81 131.16,165.81 v1(131.44,165.52) 129.57,163.65 129.57,157.88 129.67,157.78 129.74,157.78 129.84,157.67 129.84,157.47 129.74,157.37 129.67,157.37 129.57,157.27 129.57,152.08 130.81,150.84 130.89,150.84 v1(131.44,150.28) 129.54,148.38 129.54,136.95 v1(131.44,135.04) 130.25,133.85 130.25,133.22 130.38,133.09 130.43,133.09 130.53,132.99 130.53,132.68 130.43,132.58 130.33,132.58 130.25,132.51 130.25,121 v1(131.44,119.8) 130.81,119.17 130.81,111.11 133.33,108.58 133.57,108.35 143.93,108.35 145.15,109.57 v2(147.37,109.57) 155.45,109.57 156.87,110.99 157.95,110.99 158.36,111.39 160.19,111.39 161.04,112.24 163.36,112.24 164.55,113.43 164.57,113.43 164.79,113.66 164.79,113.93 165.05,114.19 167.04,114.19 167.36,114.52 167.51,114.52 v1(167.61,114.61)
  BOTTOM w0.102: R723.1 147.04,109.23 v2(147.37,109.57)
DDR_WE#: length 134
  TOP w0.102: U52.H3 137.25,118.24 137.14,118.13 v1(137.14,117.61) ; R206.1 v2(137.16,185.94) ; U39.H3 137.25,164.61 137.25,163.96 137.14,163.85 v1(137.14,163.32) ; U1.Y13 v1(167.61,118.61) ; U45.H3 137.25,148.72 137.14,148.61 v1(137.14,148.08) ; v1(137.14,178.57) 137.14,179.09 137.25,179.2 137.25,179.9 U27.H3 ; v1(137.14,132.85) 137.14,133.37 137.25,133.48 U49.H3
  L03_SIG1 w0.102: v2(137.16,185.94) 137.16,179.65 137.2,179.61 137.2,179.29 137.16,179.25 137.16,178.59 v1(137.14,178.57) 136.93,178.36 136.93,178.12 136.83,178.02 136.63,178.02 136.52,177.91 136.52,177.61 136.63,177.51 136.83,177.51 136.96,177.38 136.96,174.54 137.57,173.93 137.57,166.66 137.19,166.29 137.19,165.49 137.29,165.39 137.67,165.39 137.77,165.28 137.77,164.98 137.67,164.88 137.29,164.88 137.21,164.8 137.21,163.4 v1(137.14,163.32) 136.87,163.05 136.87,160.47 137.29,160.05 137.29,158.3 138.4,157.19 138.4,152.75 137.27,151.61 137.27,148.7 137.14,148.57 v1(137.14,148.08) 136.91,147.85 136.91,144.9 137.16,144.64 137.16,143.28 137.44,143 137.44,140.73 137.19,140.48 137.19,139 137.36,138.83 137.36,137.94 137.19,137.76 137.19,137.27 137.27,137.19 137.85,137.19 137.95,137.09 137.95,136.78 137.85,136.68 137.32,136.68 137.24,136.6 137.24,133.43 137.14,133.33 v1(137.14,132.85)
  L08_SIG2 w0.102: v1(137.14,117.61) 137.14,118.15 137.2,118.22 137.2,121.09 137.41,121.3 137.41,122.32 137.92,122.82 137.92,123.47 137.82,123.57 137.59,123.57 137.49,123.67 137.49,123.98 137.59,124.08 137.82,124.08 137.92,124.18 137.92,124.58 137.82,124.68 137.74,124.68 137.64,124.78 137.64,124.99 137.74,125.09 137.82,125.09 137.92,125.19 137.92,127.06 137.14,127.84 v1(137.14,132.85)
  BOTTOM w0.102: v1(137.14,117.61) 137.61,117.13 139.27,117.13 140.18,116.22 141.55,116.22 141.73,116.04 145.32,116.04 145.42,115.94 146.53,115.94 147.14,116.55 147.14,117.11 147.04,117.21 146.33,117.21 146.23,117.31 146.23,117.52 146.33,117.62 147.04,117.62 147.14,117.72 147.14,118.44 147.29,118.59 147.62,118.59 147.73,118.48 147.73,117.46 147.8,117.39 147.8,117.36 148.18,117.36 148.28,117.46 148.28,118.7 148.39,118.81 148.72,118.81 148.84,118.68 148.84,117.52 149,117.36 153.54,117.36 154.86,117.36 155.43,117.92 155.43,119.78 155.55,119.9 155.8,119.9 155.93,119.77 155.93,117.64 156.04,117.54 156.29,117.54 156.39,117.64 156.39,119.04 156.54,119.19 156.72,119.19 156.9,119.01 156.9,117.87 157.02,117.74 157.31,117.74 157.46,117.9 157.46,118.12 157.71,118.38 158.65,118.38 159.38,119.12 162.22,119.12 162.45,118.89 162.45,118.65 162.54,118.56 162.8,118.56 162.89,118.65 162.89,118.91 162.99,119.01 163.18,119.01 163.34,118.86 163.34,118.47 163.43,118.38 163.75,118.38 163.86,118.48 163.86,119.67 163.93,119.75 164.29,119.75 164.36,119.67 164.36,119.14 164.49,119.01 167.21,119.01 v1(167.61,118.61)
DIP_SW_B0: length 60.4
  TOP w0.127: U20.P4 v1(71.93,193.75) ; SW3.1 80.47,233.77 80.09,234.15 v2(79.88,234.15) R176.2
  L03_SIG1 w0.127: v2(63.25,196.71) 63.5,196.46 66.07,196.46 66.68,195.85 66.68,193.97 67.79,192.85 67.79,192.85 68.12,192.52 69.82,192.52 71.05,193.75 v1(71.93,193.75)
  L08_SIG2 w0.127: v2(79.88,234.15) 80.52,233.52 80.52,232.04 80.26,231.79 79.63,231.79 78.87,231.04 78.87,229.65 63.27,214.05 63.27,196.74 v2(63.25,196.71)
DIP_SW_B1: length 63.4
  TOP w0.102: U20.R2 70.64,194.02 70.33,194.02 69.93,193.62 69.77,193.62 69.69,193.54 68.83,193.54
  TOP w0.127: 68.83,193.54 65.33,193.54 64.45,192.66 63.03,192.66 61.95,193.74 60.22,193.74 59.56,193.08 v2(59.56,193.05) ; SW3.2 80.34,232.5 80.21,232.63 v2(79.88,232.63) R184.2
  L08_SIG2 w0.127: v2(59.56,193.05) 59.56,197.63 62.99,201.06 62.99,214.11 78.49,229.6 78.49,231.23 v2(79.88,232.63)
DIP_SW_B2: length 60.4
  TOP w0.102: U20.R1 70.21,193.51 70.21,193.51 70.12,193.42 69.86,193.42 68.87,192.43 68.83,192.43
  TOP w0.127: SW3.3 80.34,231.23 80.21,231.1 v2(79.88,231.1) R191.2 ; 68.83,192.43 67.71,192.43 67.33,192.05 63.11,192.05 62.48,192.67 60.83,192.67 v2(60.32,193.18)
  L08_SIG2 w0.127: v2(79.88,231.1) 79.12,230.34 79.12,229.45 63.7,214.04 63.7,196.52 63.28,196.1 62.32,196.1 60.32,194.11 v2(60.32,193.18)
DIP_SW_B3: length 61.7
  TOP w0.102: 68.83,192.15 68.92,192.15 69.93,193.16 70.36,193.16 U20.T1
  TOP w0.127: SW3.4 80.26,229.96 v2(79.88,229.58) R198.2 ; v2(59.56,192.29) 62.36,192.29 62.88,191.77 67.45,191.77 67.83,192.15 68.83,192.15
  L08_SIG2 w0.127: v2(79.88,229.58) 79.88,227.34 75.31,222.77 74.56,222.77 69.06,217.27 67.65,217.27 63.98,213.6 63.98,196.19 60.08,192.29 v2(59.56,192.29)
DIR: length 29.8
  TOP w0.127: U67.1 175.21,95.17 v2(175.59,95.54) ; R499.2 178.94,85.84 179.41,85.37 v2(180.56,85.37) ; U67.24 166.01,95.09 v2(165.53,95.57)
  L08_SIG2 w0.127: v2(165.53,95.57) 166.29,94.81 174.85,94.81 v2(175.59,95.54)
  BOTTOM w0.127: v2(180.56,85.37) 179.31,85.37 178.94,85.74 R499.2 178.2,86.49 177.8,86.88 177.8,89.18 175.92,91.06 175.92,95.21 v2(175.59,95.54)
DISP_EN: length 5.5
  TOP w0.127: J22.31 49.64,63.15 49.48,63.31 v2(49.48,64.74) 49.48,65.81 R471.1
  BOTTOM w0.127: R728.2 v2(49.48,64.74)
DSS_3V3: length 258.4
  TOP w0.254: U80.5 111.44,21.01 111.43,21.02 v2(111.43,22.62) ; U82.L4 v1(129.65,63.32) ; U81.C4 v1(162.25,63.71) ; U81.L3 v1(155.05,65.31) ; U81.P3 v1(152.65,65.31) ; U82.C4 v1(136.85,63.32) ; U82.F4 v1(134.45,63.32) ; U82.P3 v1(127.25,64.92) ; U81.L4 v1(155.05,63.71) ; U82.C3 v1(136.85,64.92) ; U81.P4 v1(152.65,63.71) ; U81.C3 v1(162.25,65.31) ; U81.F4 v1(159.85,63.71) ; U82.L3 v1(129.65,64.92) ; U82.P4 v1(127.25,63.32) ; U81.F3 v1(159.85,65.31) ; U82.F3 v1(134.45,64.92)
  TOP w0.381: R809.2 v2(136.3,45.73) ; R520.2 v2(142.01,51.38)
  TOP w0.508: v2(210.34,94.58) 213.94,98.19 213.94,105.3 218.57,109.92 218.57,120.08 221.72,123.23 221.72,131.21 232,141.49 232,147.77 229.23,150.54 R858.2
  L03_SIG1 w0.102: 162.59,67.66 162.46,67.66 161.87,67.07 161.87,67.06 161.87,66.75 161.87,66.75 161.87,66.26 161.87,66.26 161.87,65.95 161.87,65.95 161.87,65.69 v1(162.25,65.31) 162.66,65.71 162.66,67.58 162.61,67.63
  L03_SIG1 w0.381: v2(142.01,51.38) 141.22,50.59 141.22,40.76 138.53,38.06 122.3,38.06 119.35,35.12 119.35,32.35 111.43,24.42 v2(111.43,22.62) ; 162.61,67.63 162.59,67.66 163.07,67.66 164.26,68.85 v2(164.26,69.92) v2(166.22,69.92)
  L08_SIG2 w0.381: v1(127.25,64.92) v1(127.25,63.32) ; v1(129.65,64.92) 129.65,64.8 ; 129.65,64.8 v1(129.65,63.32) ; 129.65,64.8 130.2,64.25 133.86,64.25 134.47,64.86 134.47,64.9 v1(134.45,64.92) v1(134.45,63.32)
  BOTTOM w0.254: C304.1 111.1,20.12 111.43,20.45 v2(111.43,22.62)
  BOTTOM w0.381: v1(127.25,64.92) 127.25,64.27 C306.1 C300.1 129.65,64.17 v1(129.65,64.92) ; v2(136.3,45.73) 139.95,45.73 142.04,47.82 142.04,50.78 142.01,50.81 v2(142.01,51.38) ; v1(162.25,63.71) 162.25,64.32 C298.1 162.25,64.75 v1(162.25,65.31) ; v1(134.45,64.92) 134.56,64.81 C301.1 C302.1 136.56,64.62 v1(136.85,64.92) ; v1(159.85,65.31) 159.85,64.71 C309.1 159.85,64.35 v1(159.85,63.71) ; C297.1 152.65,64.72 v1(152.65,65.31) ; v1(155.05,65.31) 155.12,65.24 155.12,64.71 155.32,64.51 C299.1
  BOTTOM w0.508: v2(166.22,69.92) 169.42,66.72 180.47,66.72 183.36,63.82 202.39,63.82 209.55,70.98 209.55,77.69 207.42,79.82 207.42,92.27 209.73,94.58 v2(210.34,94.58)
EEPROM_A1: length 3.9
  TOP w0.127: U38.2 205.87,169.63 206.56,168.94 R698.2 R315.1
EEPROM_A2: length 3.7
  TOP w0.127: R701.1 R321.2 206.02,170.47 205.84,170.28 U38.3
EEPROM_WP: length 203.9
  TOP w0.127: v2(200.28,169.63) U38.7 196.84,169.63 196.26,170.21 R318.1 ; v2(162.08,197.56) 162.08,190.11 174.37,177.81 182.91,177.81 186.13,181.04 186.13,184.19 185.45,184.88 180.29,184.88 v2(179.91,184.5) ; U33.18 62.48,175.74 v2(61.98,176.24)
  L03_SIG1 w0.127: v2(61.98,176.24) 61.98,177.8 65.1,180.91 80.77,180.91 81.64,181.78 81.64,184.06 81.08,184.62 81.08,186.06 81.71,186.69 82.44,186.69 86.11,183.02 89.28,183.02 89.66,183.4 89.79,183.4 91.57,185.18 91.57,185.31 92.84,186.58 92.84,188.99 97.41,193.56 97.41,195.09 99.19,196.86 110.44,196.86 111.19,196.12 117.89,196.12 120.28,198.5 124.74,198.5 125.68,197.56 v2(162.08,197.56)
  BOTTOM w0.127: v2(200.28,169.63) 200.28,174.67 189.92,185.03 180.44,185.03 v2(179.91,184.5)
ELF1: length 6.8
  TOP w0.127: U62.41 143.75,94.01 143.25,94.51 143.25,95.23 141.86,96.63 C254.1 R461.1
EMA_A0: length 8.7
  TOP w0.127: U17.C14 v1(244.62,57.25)
  L08_SIG2 w0.127: v2(249.28,59.88) 249.28,59.3 248.39,58.41 247.35,58.41 245.77,56.83 245.59,56.83 245.58,56.84 245.26,56.84 245.25,56.83 245.03,56.83 v1(244.62,57.25)
  BOTTOM w0.127: RA14.3 249.91,59.25 v2(249.28,59.88)
EMA_A1: length 6.9
  TOP w0.127: U17.D15 v1(245.42,56.45)
  L08_SIG2 w0.102: v2(249.15,58.49) 248.56,57.9 247.28,57.9 245.83,56.45 v1(245.42,56.45)
  BOTTOM w0.127: v2(249.15,58.49) 249.54,58.09 RA14.1
EMA_A2: length 8.6
  TOP w0.127: U17.B14 v1(244.62,58.05)
  L08_SIG2 w0.127: v2(250.04,59.88) 249.4,60.52 248.31,60.52 247.42,59.63 247.42,59.04 246.02,57.65 245.02,57.65 v1(244.62,58.05)
  BOTTOM w0.127: RA14.4 250.05,59.9 v2(250.04,59.88)
EMA_A3: length 8
  TOP w0.127: U17.D14 v1(244.62,56.45)
  L08_SIG2 w0.127: v1(244.62,56.45) 245.03,56.04 245.84,56.04 247.35,57.55 248.84,57.55 v2(249.91,58.61)
  BOTTOM w0.127: RA14.2 250.04,58.74 v2(249.91,58.61)
EMA_A4: length 1.5
  TOP w0.127: U17.A14 v1(244.62,58.85)
  BOTTOM w0.127: v1(244.62,58.85) 244.83,59.06 244.83,59.12 244.97,59.26 RA11.1
EMA_A5: length 3.2
  TOP w0.127: U17.C13 v1(243.82,57.25)
  BOTTOM w0.127: RA11.2 244.32,59.25 244.22,59.15 244.22,57.65 v1(243.82,57.25)
EMA_A6: length 4.9
  TOP w0.127: U17.E13 v1(243.82,55.65)
  BOTTOM w0.127: v1(243.82,55.65) 243.43,56.04 243.43,58.62 243.18,58.87 243.18,59.67 RA11.4
EMA_A7: length 2.2
  TOP w0.127: U17.B13 v1(243.82,58.05)
  BOTTOM w0.127: v1(243.82,58.05) 243.82,58.48 243.81,58.49 RA11.3
EMA_A8: length 6.3
  TOP w0.127: RA5.3 245.72,62.04 245.35,61.67 245.35,60.38 245.23,60.26 245.23,60.08 245.58,59.73 245.58,59.55 245.4,59.37 245.22,59.37 244.87,59.72 244.69,59.72 U17.A13
EMA_A9: length 8.6
  TOP w0.127: U17.D12 v1(243.02,56.45) ; v2(245.97,61.53) 246.37,61.93 RA5.4
  L08_SIG2 w0.127: v1(243.02,56.45) 243.43,56.85 243.43,58.21 243.43,58.22 243.43,58.46 244.73,59.76 245.49,59.76 245.97,60.24 v2(245.97,61.53)
EMA_A10: length 9.7
  TOP w0.127: U17.C12 v1(243.02,57.25) ; RA5.1 243.44,62.6 v2(243.12,62.93)
  L08_SIG2 w0.127: v1(243.02,57.25) 243.02,58.5 244.78,60.26 244.78,62.12 244.07,62.83 243.22,62.83 v2(243.12,62.93)
EMA_A11: length 6.7
  TOP w0.127: U17.B12 243,58.03 243,58.74 243.53,59.27 243.53,59.45 243.38,59.6 243.38,59.78 243.56,59.96 243.74,59.96 243.89,59.81 244.07,59.81 245,60.73 245,61.83 245.21,62.04 RA5.2
EMA_A12: length 5.8
  TOP w0.127: U17.D13 v1(243.82,56.45)
  BOTTOM w0.127: RA12.3 246.61,59.12 245.93,58.45 245.17,58.45 245.02,58.3 245.02,57.03 244.84,56.84 244.2,56.84 244.07,56.71 244.07,56.69 v1(243.82,56.45)
EMA_BA0: length 3.7
  TOP w0.127: U17.C15 v1(245.42,57.25)
  BOTTOM w0.127: RA12.2 247.12,58.94 v1(245.42,57.25)
EMA_BA1: length 1.6
  TOP w0.127: U17.A15 v1(245.42,58.85)
  BOTTOM w0.127: RA12.4 245.96,59.49 245.42,58.95 v1(245.42,58.85)
EMA_D0: length 40.4
  TOP w0.127: RA2.8 249.28,75.64 v2(249.66,75.26) ; U17.C9 v1(239.82,57.25)
  L03_SIG1 w0.102: v1(239.82,57.25) 239.82,57.73 239.12,58.43 235.51,58.43 235.31,58.64 235.31,59.17 235.58,59.45 247.8,59.45
  L03_SIG1 w0.127: v2(249.66,75.26) 249.71,75.26 252.4,72.57 252.4,63.16 249.91,60.67 249.02,60.67 247.8,59.45
EMA_D1: length 41.3
  TOP w0.127: v2(249.06,74.36) 248.51,74.36 248.39,74.49 RA2.6 ; v2(238.8,62.57) 238.28,62.05 238.28,61.48 239.42,60.34 U17.A8
  L03_SIG1 w0.127: v2(249.06,74.36) 249.15,74.27 249.15,72.91 248.89,72.66 248.46,72.66 247.79,73.33 245.39,73.33 244.28,74.44 244.28,74.64 244.28,75.72 242.78,77.23 235.5,77.23 234.34,76.07 234.34,67.3 236.85,64.78 237.69,64.78 238.8,63.68 v2(238.8,62.57)
EMA_D2: length 40.5
  TOP w0.127: v2(248.64,75) RA2.7 ; U17.B8 239.8,58.03 239.8,60.78 v2(238.8,61.79)
  L03_SIG1 w0.102: 243.36,75.35 242.21,75.35 241.96,75.1 241.96,73.38 241.29,72.71 235.1,72.71
  L03_SIG1 w0.127: 243.36,75.35 243.89,75.35 244.02,75.22 244.02,73.9 244.83,73.09 247.69,73.09 248.36,72.42 248.99,72.42 249.52,72.94 249.52,74.55 249.07,75 v2(248.64,75) ; v2(238.8,61.79) 239.29,62.28 239.29,63.57 237.82,65.04 236.96,65.04 234.67,67.32 234.67,72.28 235.1,72.71
EMA_D3: length 41.8
  TOP w0.127: RA2.5 249.71,73.84 249.85,73.98 v2(250.29,73.98) ; U17.E8 v1(239.02,55.65)
  L03_SIG1 w0.102: v1(239.02,55.65) 239.4,56.03 239.4,57.67 238.86,58.21 234.59,58.21 234.26,58.54 234.26,59.3 234.65,59.68 247.57,59.68
  L03_SIG1 w0.127: v2(250.29,73.98) 252.16,72.11 252.16,64.27 247.57,59.68
EMA_D4: length 40.7
  TOP w0.127: v2(237.46,64.07) 236.42,63.03 236.42,60.59 237.42,59.59 237.42,58.05 U17.B5 ; RA4.8 248.27,72.85 v2(248.64,73.22)
  L03_SIG1 w0.127: v2(237.46,64.07) 237.06,64.07 232.99,68.14 232.99,75.33 235.18,77.51 242.84,77.51 244.53,75.82 244.53,74.54 245.49,73.57 248.28,73.57 v2(248.64,73.22)
EMA_D5: length 41.3
  TOP w0.127: U17.E7 v1(238.22,55.65) ; RA4.7 v2(250.66,72.2)
  L03_SIG1 w0.127: v2(250.66,72.2) 249.76,71.3 249.76,63.73 248.51,62.48 248.51,61.26 247.21,59.96 233.71,59.96 233.4,59.66 233.4,57.32 233.86,56.86 234.85,56.86 235.92,57.93 238.3,57.93 238.61,57.62 238.61,56.04 v1(238.22,55.65)
EMA_D6: length 40.5
  TOP w0.127: U17.C6 v1(237.42,57.25) ; v2(249.26,71.44) 249.01,71.69 RA4.6
  L03_SIG1 w0.102: 232.26,55.59 232.38,55.46 235.64,55.46 v1(237.42,57.25)
  L03_SIG1 w0.127: v2(249.26,71.44) 248.31,71.44 248.04,71.17 248.04,66.12 248.44,65.72 248.44,63.54 247.95,63.05 247.95,61.38 247.04,60.47 232.36,60.47 232.08,60.19 232.08,55.77 232.26,55.59
EMA_D7: length 40.7
  TOP w0.127: RA4.5 248.65,71.05 v2(248.89,70.8) ; U17.D7 v1(238.22,56.45)
  L03_SIG1 w0.127: v2(248.89,70.8) 249.39,70.31 249.39,63.76 248.23,62.6 248.23,61.32 247.13,60.21 232.46,60.21 232.36,60.11 232.36,55.95 232.63,55.68 235.52,55.68 235.74,55.89 235.74,57.16 236.25,57.67 237.64,57.67 237.82,57.5 237.82,56.85 v1(238.22,56.45)
EMA_D8: length 42.3
  TOP w0.127: U17.E10 v1(241.42,55.65) ; RA3.8 230.97,72.7 230.73,72.46 v2(230.73,71.82)
  L08_SIG2 w0.127: v2(230.73,71.82) 230.3,71.82 230.19,71.7 230.19,71.39 230.61,70.97 230.61,62.3 230.73,62.17 231.04,62.17 231.17,62.05 231.17,61.79 231.04,61.66 230.73,61.66 230.61,61.54 230.61,61.28 230.73,61.16 231.04,61.16 231.17,61.03 231.17,60.78 231.04,60.65 230.73,60.65 230.61,60.52 230.61,60.27 230.73,60.14 231.04,60.14 231.17,60.01 231.17,59.76 231.04,59.63 230.73,59.63 230.61,59.51 230.61,59.25 230.73,59.12 231.04,59.12 231.17,59 231.17,58.74 231.04,58.62 230.73,58.62 230.61,58.49 230.61,56.5 231.98,55.13 231.98,51.17 232.71,50.44 235.18,50.44 235.18,50.44 235.89,51.15 235.89,55.77 236.17,56.05 241.02,56.05 v1(241.42,55.65)
EMA_D9: length 41.3
  TOP w0.127: v2(230.35,72.86) 230.84,73.34 RA3.7 ; U17.D9 v1(239.82,56.45)
  L08_SIG2 w0.127: v1(239.82,56.45) 239.43,56.84 237.08,56.84 236.93,56.99 236.93,57.32 236.83,57.42 235.51,57.42 235.38,57.29 235.38,53.84 235.18,53.64 232.63,53.64 232.46,53.81 232.46,56.92 232.33,57.05 231.84,57.05 231.71,57.18 231.71,57.43 231.84,57.56 232.33,57.56 232.46,57.68 232.46,57.94 232.33,58.07 231.84,58.07 231.71,58.19 231.71,58.45 231.84,58.57 232.33,58.57 232.46,58.7 232.46,58.95 232.33,59.08 231.84,59.08 231.71,59.21 231.71,59.46 231.84,59.59 232.33,59.59 232.46,59.72 232.46,59.97 232.33,60.1 231.84,60.1 231.71,60.22 231.71,60.48 231.84,60.61 232.33,60.61 232.46,60.73 232.46,60.99 232.33,61.11 231.84,61.11 231.71,61.24 231.71,61.49 231.84,61.62 232.33,61.62 232.46,61.75 232.46,62 232.33,62.13 231.84,62.13 231.71,62.26 231.71,62.51 231.84,62.64 232.33,62.64 232.46,62.76 232.46,63.35 232.08,63.73 232.08,71.95 231.17,72.86 v2(230.35,72.86)
