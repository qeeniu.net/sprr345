# Allegro board PROC046_REVA_BOARD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PLL1_VSSA: length 20.5
  TOP w0.254: U17.M15 v1(245.42,49.25)
  TOP w0.381: FL15.2 251.64,35.63 252.2,36.19 v2(252.2,37.78)
  BOTTOM w0.381: C459.2 251.41,37 v2(252.2,37.78) 250.93,39.05 250.93,43.78 249.18,45.53 C94.1 248.4,45.6 247.72,46.28 247.38,46.28 246.37,47.29 246.37,48.3 v1(245.42,49.25)
PLL_LOCK: length 151.2
  TOP w0.127: U62.46 v2(141.25,93.77) ; U20.R3 v1(71.43,193.31)
  L03_SIG1 w0.127: v2(71.07,185.82) 74.15,182.74 80.14,182.74 v2(80.99,181.88)
  L08_SIG2 w0.102: 71.02,190.16 71.02,192.9 v1(71.43,193.31)
  L08_SIG2 w0.127: 71.02,190.16 71.07,190.11 v2(71.07,185.82) ; v2(80.99,181.88) 80.87,181.88 80.87,182.03 81.37,181.54 81.37,159.99 106.68,134.68 109.36,132 109.36,98.15 113.26,94.25 116.16,94.25 116.8,93.61 131.11,93.61 132.18,92.54 138.24,92.54 138.25,92.52 140,92.52 v2(141.25,93.77)
PMBUS_I2C_EN: length 26.4
  TOP w0.127: U14.5 v2(66.59,208.4) ; U20.V16 77.93,192.71 v1(77.91,192.73)
  BOTTOM w0.102: 68.83,201.58 69.34,202.09 69.34,202.55 ; 68.83,198.92 69.22,198.54 71.48,198.54 72.77,197.25 73.53,197.25 75.5,195.28 75.68,195.28 76.43,194.53 76.76,194.53 76.96,194.32 76.96,193.97 76.78,193.79 76.78,193.11 77.16,192.73 v1(77.91,192.73)
  BOTTOM w0.127: v2(66.59,208.4) 66.59,207.36 67.18,206.77 68.99,206.77 69.34,206.42 69.34,202.55 ; 68.83,201.58 68.68,201.43 68.68,199.07 68.83,198.92
PMBUS_SCL: length 346.8
  TOP w0.127: R370.2 v2(270.87,145.41) 269.96,146.32 U42.5 v2(268.46,149.51) ; R118.2 v2(69.33,218.85) ; v2(254.55,147.5) 253.93,148.12 253.93,148.46 253.64,148.75 U43.5 ; 240.72,140.85 240.92,140.65 240.92,139.49 240.78,139.35 U46.5 239.76,139.35 239.76,138.36 240.77,137.35 250.01,137.35 250.87,138.21 U48.5 v2(253.24,138.21) ; 240.72,140.85 240.94,141.08 240.94,148.05 240.5,148.49 U44.5 ; 240.72,140.85 U46.2
  L08_SIG2 w0.127: v2(254.55,147.5) 254.14,147.1 252.97,147.1 251.92,146.05 251.92,139.77 253.24,138.44 v2(253.24,138.21)
  BOTTOM w0.127: v2(69.33,218.85) 71.5,221.02 71.5,222.75 74.27,225.52 74.27,233.98 80.28,239.99 130.49,239.99 136.51,233.97 146.05,233.97 158.5,221.53 158.5,204.35 170.83,192.01 172.87,192.01 173.23,192.37 173.23,199.43 174.89,201.1 195.45,201.1 223.16,173.39 223.16,164.7 226.28,161.59 226.28,158.9 226.8,158.38 228.43,158.38 231.9,154.92 231.9,152.92 233.27,151.55 233.3,151.55 237.6,147.25 237.6,141.33 238.84,140.1 240.86,140.1 242.84,138.11 249.18,138.11 252.22,141.16 252.22,145.18 v2(254.55,147.5) 254.86,147.19 260.19,147.19 261.33,148.33 268.05,148.33 268.46,148.74 v2(268.46,149.51) ; R370.2 v2(270.87,145.41)
PMBUS_SDA: length 350.5
  TOP w0.127: R117.2 v2(66.04,218.85) ; U44.2 240.51,149.99 240.66,149.84 240.66,149.11 240.55,148.99 U44.4 v2(238.21,148.99) ; v2(250.55,138.7) 250.55,138.71 U48.4 ; U43.4 v2(251.75,149.25) ; U46.4 v2(238.37,139.85) ; U42.4 v2(271.11,150.01) 271.11,149.57 272.5,148.17 273.71,148.17 274.73,147.16 274.73,145.55 R374.2 275.92,145.43 275.93,145.41 R371.2
  L08_SIG2 w0.127: v2(238.21,148.99) 238.21,140.46 238.37,140.29 v2(238.37,139.85)
  BOTTOM w0.127: v2(238.21,148.99) 239.72,147.49 243.08,147.49 243.89,146.67 250.57,146.67 251.75,147.85 v2(251.75,149.25) ; v2(271.11,150.01) 270.8,149.7 270.8,147.9 269.39,146.5 266.7,146.5 265.63,145.43 259.97,145.43 258.62,146.78 254.2,146.78 252.5,145.07 252.5,141.1 250.55,139.14 v2(250.55,138.7) 249.68,137.84 242.72,137.84 240.71,139.85 v2(238.37,139.85) 237.36,140.86 237.36,147.09 233.18,151.27 233.16,151.27 231.52,152.91 231.52,154.9 228.32,158.1 226.67,158.1 226.03,158.74 226.03,161.43 222.88,164.58 222.88,173.27 195.34,200.82 175.01,200.82 173.51,199.31 173.51,192.24 173,191.73 170.71,191.73 158.22,204.23 158.22,221.41 145.93,233.69 136.4,233.69 130.34,239.75 80.38,239.75 74.51,233.88 74.51,225.3 71.74,222.53 71.74,220.64 69.25,218.15 66.74,218.15 v2(66.04,218.85)
PMIC_GPIO2: length 169.6
  TOP w0.127: R330.2 230.25,160.42 228.7,161.97 226.54,161.97 v2(224.92,163.59) ; R907.2 276.07,202.71 275.94,202.83 257.05,202.83 255.14,200.93 229.36,200.93 225.93,204.36 v2(225.93,219.72)
  L03_SIG1 w0.127: v2(233.68,236.62) 233.68,236.18 235.2,234.66 235.2,221.12 233.81,219.72 v2(225.93,219.72) 224.49,218.28 224.49,164.02 v2(224.92,163.59)
  BOTTOM w0.127: R703.2 230.86,160.42 230.56,160.72 227.99,160.72 227.53,160.26 226.92,160.26 226.62,160.57 226.62,161.89 v2(224.92,163.59) ; R851.2 233.68,237.26 v2(233.68,236.62)
PMIC_HDRST: length 40.4
  TOP w0.102: v2(246.38,171.08) 246.47,171 U32.L6
  TOP w0.127: SW8.2 SW8.1 270.61,167.05 270.38,167.27 270.38,170.07 D12.1 269.49,170.32 v2(269.24,170.58)
  L03_SIG1 w0.127: v2(246.38,171.08) 249,171.08 249.83,170.25 253.85,170.25 256.39,167.71 268.02,167.71 269.24,168.92 v2(269.24,170.58)
PMIC_PGOOD: length 16.9
  TOP w0.102: U32.C4 244.83,176.05 242.79,176.05 242.61,176.23 242.57,176.25 242.56,176.27 242.46,176.37
  TOP w0.127: 242.46,176.37 242.27,176.56 242.27,177.54 242.7,177.97 242.7,179.16
  TOP w0.254: 242.7,179.16 241.88,179.97
  TOP w0.381: 241.88,179.97 241.33,180.53 241.33,183.5 239.27,185.56 236.73,185.56 TP85.1
PMIC_PWRHOLD: length 20.2
  TOP w0.102: v2(242.82,168.8) 242.82,168.82 U32.N1
  L03_SIG1 w0.127: v2(242.82,168.8) 237.57,163.54 237.57,157.57 J13.2
PMIC_PWRON: length 73.4
  TOP w0.102: U32.E4 245.17,174.42 v1(245.49,174.09)
  TOP w0.127: v2(281.18,170.32) D13.1 282.12,167.78 281.36,167.02 R334.2 280.16,164.86 280.8,164.23 288.12,164.23 289.02,165.13 SW9.2 SW9.1
  L08_SIG2 w0.127: v1(245.49,174.09) 245.07,174.09 244.73,173.75 244.35,173.75 244.11,173.99 244.11,175.03 244.93,175.86 245.29,175.86 245.3,175.86 245.69,175.86 245.69,175.86 247.73,175.86 249.53,177.66 256.62,177.66 258.06,179.11 259.97,179.11 261.67,177.41 264.59,177.41 265.68,176.32 278.03,176.32 281.46,172.89 281.46,170.79 281.43,170.77 281.43,170.58 v2(281.18,170.32)
PMIC_VDD1: length 99.6
  TOP w0.102: U32.D4 245.17,175.07 v1(245.49,174.74)
  TOP w0.203: U44.8 244.93,149.49 245.03,149.6 245.03,150.29 ; 245.03,150.29 244.83,150.49 U44.10 ; 245.03,150.29 245.03,151.68 245.11,151.75 245.03,151.75 v2(245.03,151.89)
  TOP w0.381: C110.2 v2(238,183.4) ; R360.2 v2(248.03,154.07)
  TOP w0.508: J41.1 243.64,154.95 ; J41.1 241.5,154.95 ; J41.1 242.57,156.02 ; J41.1 242.57,153.89
  L03_SIG1 w0.381: 241.12,183.23 241.58,182.77 241.58,176.77 242.24,176.11 242.52,176.11 242.54,176.09 243,176.09 243.03,176.11 244.56,176.11 244.93,175.74 244.93,175.07 245.23,174.77 245.46,174.77
  L03_SIG1 w0.508: 242.57,153.89 J41.1 ; J41.1 243.64,154.95 ; J41.1 242.57,156.02 ; 239.85,183.48 v2(239.9,183.53) ; 245.46,174.77 v1(245.49,174.74)
  L03_SIG1 w1.016: v2(231.98,185.36) 231.09,185.36 231.04,185.31 228.07,185.31 225.45,182.69 225.45,165.62 229.54,161.53 230.94,161.53 232.18,160.29 232.18,158 228.78,154.6 228.78,152.49 230.28,150.99 238.12,150.99 239.8,152.67 242.7,152.67 242.82,152.54 ; 242.82,152.54 245.11,154.83 v2(247.01,154.83) ; 242.82,152.54 242.14,152.54
  BOTTOM w0.381: 245,150.61 245,152.53 J41.1
  BOTTOM w0.508: J41.1 243.64,154.95 ; J41.1 241.5,154.95 ; J41.1 242.57,153.89
  vias: v2(233.3,185.31) v2(233.3,184.29) v2(237.11,184.04) v2(237.11,183.02) v2(238.38,184.04) v2(244.2,151.6) v2(245.75,151.7) v2(247.01,154.07) v2(248.03,154.83) v2(249.05,154.83) v2(249.05,154.07)
PMIC_VDD2: length 230.6
  TOP w0.102: 135.38,112.28 135.67,112.57 v1(135.67,113.69) ; U32.K2 v1(243.54,170.84) ; U52.E2 140.06,120.3 140.06,121.07 ; U49.G2 138.05,135.14 ; 140.03,135.51 140.03,136.21 ; U52.G2 138.05,119.9
  TOP w0.203: U48.8 257.38,139.21 257.52,139.06 258.71,139.06 258.98,139.33 258.98,140.1 258.53,140.55 257.86,140.55 v2(257.52,140.21) U48.10
  TOP w0.254: v1(134.05,151.89) 134.05,151.89 U45.M1 ; v1(137.64,129.93) 138.04,130.33 U49.G8 ; v1(134.45,175.65) 134.05,175.26 U27.M9 ; U45.A9 v1(143.25,144.37) ; U49.E9 139.65,129.05 v1(139.55,128.94) ; 138.05,135.14 v1(137.65,135.53) ; U27.G2 137.65,181.24 v1(137.65,181.25) ; U39.E2 139.65,165.61 v1(140.05,166.01) ; U27.G8 138.04,176.05 v1(137.64,175.65) ; v1(134.05,182.37) 134.05,181.88 134.05,181.88 U27.M1 ; v1(140.05,150.77) 139.65,150.37 U45.E2 ; U27.K9 135.65,174.95 135.65,174.94 135.65,174.67 v1(135.67,174.65) ; U39.E9 139.65,159.53 139.55,159.42 v1(139.55,159.2) ; v1(134.05,121.41) 134.05,120.69 U52.M1 ; v1(139.55,144.18) 139.65,144.29 U45.E9 ; U52.K9 135.67,114.27 v1(135.67,113.69) ; U45.M9 134.05,144.78 v1(134.45,145.17) ; U49.A9 v1(143.25,129.13) ; v1(135.65,136.54) 135.65,136.54 U49.K1 ; v1(140.75,177.38) 140.45,177.08 U27.D7 ; U39.A9 v1(143.25,159.61) ; v1(139.55,113.7) 139.65,113.81 U52.E9 ; v1(137.65,166.01) 138.05,165.62 U39.G2 ; C130.2 115.06,197.01 U25.5 ; v1(139.52,137.61) 140.03,137.09 140.03,136.21 ; U45.K9 135.65,144.19 v1(135.67,144.17) ; v1(135.65,167.02) 135.65,167.02 135.65,166.74 U39.K1 ; U45.D7 140.45,146.6 v1(140.75,146.9) ; v1(140.75,131.66) 140.45,131.36 U49.D7 ; v1(134.05,167.13) 134.05,166.79 134.05,166.79 U39.M1 ; U52.G8 138.04,115.09 v1(137.64,114.69) ; v1(135.65,151.78) 135.65,151.78 U45.K1 ; U27.E2 139.65,180.85 v1(140.05,181.25) ; U49.K9 135.67,129.51 v1(135.67,128.93) ; U39.K9 135.65,159.43 v1(135.67,159.41) ; v1(134.45,129.93) 134.05,129.54 U49.M9 ; 138.05,119.9 v1(137.65,120.29) ; v1(134.45,114.69) 134.05,114.3 U52.M9 ; U52.A9 v1(143.25,113.89) ; U27.B9 v1(142.45,174.85) ; U52.C1 v1(141.65,121.09) ; v1(134.05,136.65) 134.05,135.93 U49.M1 ; U39.B9 v1(142.45,159.61) ; U27.E9 139.65,174.77 v1(139.55,174.66) ; U52.B9 v1(142.45,113.89) ; U49.B9 v1(142.45,129.13) ; v1(140.75,162.14) 140.45,161.84 U39.D7 ; v1(134.45,160.41) 134.05,160.02 U39.M9 ; v1(135.65,182.26) 135.65,182.26 135.65,181.93 135.65,181.93 U27.K1 ; v1(137.65,150.77) 138.05,150.38 U45.G2 ; U27.A9 v1(143.25,174.85) ; v1(137.64,160.41) 138.04,160.81 U39.G8 ; U45.G8 138.04,145.57 v1(137.64,145.17) ; U27.C1 v1(141.65,182.05) ; U49.E2 140.03,135.51 ; U39.C1 v1(141.65,166.81) ; v2(140.92,122.95) 140.92,121.93 140.06,121.07 ; U45.C1 v1(141.65,151.57) ; v1(135.65,121.3) 135.65,121.3 U52.K1 ; U45.B9 v1(142.45,144.37)
  TOP w0.305: v1(143.93,120.32) 143.5,119.89 U52.A2 ; v1(143.93,135.56) 143.28,135.56 U49.A2 ; U39.A2 143.37,166.13 v1(143.76,166.13) ; v1(141.43,137.25) 141.48,137.2 141.48,136.64 141.25,136.41 U49.C1 ; U45.A2 143.28,150.8 v1(143.93,150.8) ; C605.1 142.23,121.67 v1(141.65,121.09) ; v2(144.73,180.2) 144.08,180.85 U27.A2
  TOP w0.381: R383.2 264.88,144.43 264.6,144.16 v2(264.03,144.16) ; R383.2 267.67,145.13 v2(266.85,145.94) ; R383.2 268.85,144.43 269.19,144.77 v2(270.08,144.77) ; C130.2 v2(115.95,196.99) ; 135.38,112.28 v2(135.38,111.65) ; v1(139.55,113.7) 139.55,112.18 139.89,111.84 C603.1 ; v1(140.85,115.48) 140.45,115.88 U52.D7 ; C148.2 238,164.21 237.76,163.97 v2(237.11,163.97)
  TOP w0.508: TP113.1 230.43,164.48 ; TP113.1 229.23,165.67 ; TP113.1 229.23,163.29 ; TP113.1 228.04,164.48
  L03_SIG1 w0.508: 255.47,144.54 256.16,144.54 ; J43.1 256.54,145.61 ; J43.1 256.54,143.47 ; J43.1 257.61,144.54
  L03_SIG1 w0.762: 256.16,144.54 J43.1
  L06_PWR2 w0.508: 255.47,144.54 J43.1 ; J43.1 256.54,145.61 ; J43.1 256.54,143.47 ; J43.1 257.61,144.54 ; TP113.1 229.23,165.67 ; TP113.1 230.43,164.48 ; TP113.1 228.04,164.48 ; TP113.1 229.23,163.29
  BOTTOM w0.254: v1(139.55,144.18) 140.33,143.4 C529.1 C528.1 ; C523.1 138.81,143.11 138.3,143.62 138.3,143.78 137.67,144.41 137.67,144.67 137.64,144.69 v1(137.64,145.17)
  BOTTOM w0.305: v1(135.67,144.17) 135.67,143.54 135.38,143.26 C530.1 ; v1(134.05,167.13) 133.69,167.49 133.69,168.23 C491.1 ; C462.1 138.54,175.65 v1(137.64,175.65) ; v1(143.25,174.85) 143.61,174.49 144.39,174.49 C465.1 ; v1(137.65,150.77) 137.02,150.14 C516.1 ; v1(143.25,129.13) 143.61,128.77 144.14,128.77 C563.1 ; v1(141.65,121.09) 141.65,121.48 C582.1 ; C450.1 142.45,181.24 v1(141.65,182.05) ; C444.1 136.53,181.9 136.01,181.9 v1(135.65,182.26) ; v1(140.75,177.38) 141.79,177.38 C456.1 ; C607.1 133.47,112.66 134.11,113.31 134.11,114.36 v1(134.45,114.69) ; C509.1 133.98,159.98 134.29,160.29 134.32,160.29 v1(134.45,160.41) ; v1(134.45,129.93) 133.86,129.35 C571.1 ; C568.1 140.08,131.33 140.41,131.66 v1(140.75,131.66) 141.16,131.66 C555.1 ; C475.1 140.08,174.13 v1(139.55,174.66) ; C474.1 142.45,173.59 v1(142.45,174.85) ; v1(141.43,137.25) 141.48,137.3 141.48,138.94 C541.1 ; C477.1 135.38,173.74 135.67,174.02 v1(135.67,174.65) ; C548.1 145.11,135.56 v1(143.93,135.56) 143.06,135.56 142.76,135.26 C546.1 ; C531.1 133.86,144.59 v1(134.45,145.17) ; C489.1 140.21,167.92 139.45,167.16 139.45,166.62 v1(140.05,166.01) ; C544.1 134.05,137.76 v1(134.05,136.65) ; C503.1 143.64,158.62 143.25,159.01 v1(143.25,159.61) ; v1(140.05,150.77) 140.71,150.77 C512.1 ; v1(141.65,166.81) 142.01,167.17 142.01,167.74 C488.1 ; v1(137.65,166.01) 137.02,165.38 C495.1 ; C547.1 137.02,135.25 137.3,135.53 v1(137.65,135.53) ; C608.1 137.15,119.78 v1(137.65,120.29) 137.65,121.17 C581.1 ; C449.1 137.02,181.1 137.17,181.25 v1(137.65,181.25) ; C513.1 135.37,152.44 135.65,152.16 v1(135.65,151.78) ; C506.1 142.45,158.35 v1(142.45,159.61) ; v1(134.05,151.89) 133.62,152.32 C514.1 ; v1(140.05,181.25) 140.72,181.25 C443.1 ; C583.1 140.61,120.29 140.05,120.29 139.32,121.03 C584.1 ; C543.1 135.65,137.71 v1(135.65,136.54) ; C559.1 137.02,129.3 v1(137.64,129.93) ; C502.1 136.94,160.05 137.29,160.05 v1(137.64,160.41) ; C511.1 141.65,152.74 v1(141.65,151.57) ; C579.1 135.25,122.7 135.76,122.19 135.76,121.41 v1(135.65,121.3) ; v1(134.45,175.65) 133.73,174.94 C478.1 ; C508.1 135.67,158.17 v1(135.67,159.41) ; v1(140.75,162.14) 142.2,162.14 C501.1 143,161.67 C494.1 ; v1(134.05,121.41) 133.98,121.35 133.98,120.92 133.84,120.78 C580.1 ; C490.1 135.65,168.26 v1(135.65,167.02) ; C507.1 140.08,158.61 139.55,159.15 v1(139.55,159.2) ; C517.1 145.08,150.8 v1(143.93,150.8) ; v1(139.55,128.94) 139.7,128.79 139.7,127.9 139.45,127.65 C569.1 ; v1(135.67,128.93) 135.76,128.83 135.76,128.41 135.38,128.03 C570.1
  BOTTOM w0.381: C602.1 133.62,119.84 133.35,120.11 133.35,120.78 C580.1 ; v1(143.25,144.37) 143.65,143.97 143.79,143.97 143.92,143.84 C524.1 ; C448.1 132.73,183.76 133.52,182.96 133.52,182.9 v1(134.05,182.37) ; C589.1 145.56,121.57 144.91,120.92 144.53,120.92 v1(143.93,120.32) ; C515.1 146.23,151.03 146.07,150.88 C517.1 ; v1(143.25,113.89) 143.25,113.3 C604.1 ; v1(243.54,170.84) 243.54,168.12 240.92,165.5 237.62,165.5 237.11,164.99 v2(237.11,163.97) ; v1(141.43,137.25) 141.48,137.2 141.48,136.55 C542.1 ; v1(139.55,144.18) 139.69,144.18 139.92,144.41 C522.1 ; v1(141.65,182.05) 141.23,182.46 C442.1 141.23,183.7 141.83,184.29 145.16,184.29 148.08,181.37 148.64,181.37 148.69,181.32 C428.2 v2(149.46,182.96) ; C445.1 135.78,183.24 135.65,183.11 v1(135.65,182.26) ; C606.1 v2(135.38,111.65) ; v1(143.76,166.13) 144.37,165.52 C496.1 ; R723.2 144.65,109.12 v2(144.65,108.42) ; v2(140.92,122.95) 140.52,122.95 139.99,122.43 C584.1 ; C724.1 C725.1 264.91,141.89 v2(264.85,141.95)
  BOTTOM w0.508: TP113.1 229.23,165.67 ; TP113.1 228.04,164.48 ; TP113.1 229.23,163.29 ; TP113.1 230.43,164.48
  vias: v1(138.65,183.25) v2(230.89,162.7) v2(232.54,162.7) v2(234.06,162.7) v2(255.27,142.89) v2(256.54,142.89) v2(257.81,142.89) v2(257.81,141.62) v2(259.08,142.89) v2(259.08,141.62) v2(260.35,142.89) v2(261.62,142.89)
PMIC_VDD_CTRL: length 26.3
  TOP w0.203: U43.8 256.39,149.75 256.18,149.95 256.18,150.56 256.37,150.75 U43.10
  TOP w0.254: U43.10 258.56,150.75
  TOP w0.381: 258.58,152.78 258.21,153.15 258.19,153.15 J40.1 259.21,154.7 259.81,154.1 R357.2 ; 258.58,152.78 258.56,152.78 ; 258.58,152.78 v2(259.59,151.78) 258.56,150.75
  TOP w0.508: 257.12,154.7 J40.1 258.19,155.77
  L03_SIG1 w0.508: 258.19,153.63 J40.1 ; J40.1 259.26,154.7 ; J40.1 258.19,155.77
  BOTTOM w0.381: C716.1 C715.1
  BOTTOM w0.508: 257.12,154.7 J40.1 ; J40.1 259.26,154.7 ; J40.1 258.19,155.77 ; J40.1 258.19,153.63
  vias: v2(256.54,195.72) v2(256.54,194.71) v2(257.68,195.72) v2(257.68,194.71) v2(258.32,159.27) v2(258.32,158.26) v2(258.32,157.24) v2(258.57,195.72) v2(258.57,194.71) v2(258.57,193.56) v2(258.57,192.55) v2(259.46,159.27) v2(259.46,158.26) v2(259.46,157.24) v2(259.59,195.72) v2(259.59,194.71) v2(259.59,193.56) v2(259.59,192.55) v2(260.6,159.27) v2(260.73,195.72) v2(260.73,194.71) v2(260.73,193.56) v2(260.73,192.55) v2(260.73,158.26) v2(260.73,157.24) v2(261.75,159.27) v2(261.87,195.72) v2(261.87,194.71) v2(261.87,193.56) v2(261.87,192.55) v2(261.87,158.26) v2(261.87,157.24) v2(262.89,156.1) v2(263.78,158.76) v2(264.92,158.76) v2(265.3,157.24) v2(266.06,158.76) v2(266.45,157.24) v2(267.21,158.76)
PMIC_VIO: length 144.5
  TOP w0.102: 248.28,172.39 247.84,172.39 U32.H8
  TOP w0.127: 249.33,172.61 249.11,172.39 248.28,172.39
  TOP w0.203: U32.N7 247.12,168.44 v2(247.4,168.16)
  TOP w0.254: R900.2 v2(281.69,196.64)
  TOP w0.305: v2(249.76,172.99) 249.71,172.99 249.33,172.61
  TOP w0.381: R346.1 v2(233.81,156.86) ; R330.1 233.31,160.42 234.04,161.15 v2(234.29,161.15) ; R345.1 v2(254,157.37)
  L03_SIG1 w0.381: v2(260.22,167.02) 269.49,167.02 271.27,168.8 v2(271.53,168.8)
  L08_SIG2 w0.381: 264.49,167.02 v2(260.22,167.02) ; v2(260.22,167.02) 260.22,162.75 254.84,157.37 v2(254,157.37) ; v2(260.22,167.02) 248.18,167.02 247.5,167.71 247.5,168.06 v2(247.4,168.16) 246.71,167.48 246.71,165.45 248.41,163.74 248.41,163.08 243.71,158.38 238.5,158.38 237.52,157.4 237.52,157.39 237.24,157.11 237.24,156.22 236.47,155.46 234.44,155.46 233.81,156.1 v2(233.81,156.86) 234.44,157.49 234.44,160.42 234.29,160.58 v2(234.29,161.15)
  L08_SIG2 w0.508: v2(249.76,172.99) 252.07,172.99 252.65,173.57 255.83,173.57 257,172.4 258.44,172.4 258.93,172.89 263.25,172.89 265.25,170.88 265.25,167.78 264.49,167.02
  BOTTOM w0.381: v2(271.53,168.8) 283.72,168.8 284.86,169.94 284.86,195.21 283.46,196.61 281.71,196.61 v2(281.69,196.64)
PORN: length 15.4
  TOP w0.127: U24.16 91.17,185.41 91.95,186.2 95,186.2 95.5,185.69 95.5,182.39 96.39,181.5 98.3,181.5 98.69,181.1 R249.1 99.7,180.1 99.71,180.12 U26.1
PRSNT1#: length 270.9
  TOP w0.127: R596.1 v2(203.71,220.49) ; U1.AB23 v1(166.01,110.61)
  L03_SIG1 w0.102: v1(166.01,110.61) 165.61,111.01 165.02,111.01 162.99,108.98 161.37,108.98 161.21,109.13
  L03_SIG1 w0.127: 161.21,109.13 158.09,109.13 156.57,107.61 155.27,107.61 154.36,106.7 153.39,106.7 153.06,106.37 153.06,105.21 152.21,104.36 149.81,104.36 149.33,104.84 130.02,104.84 128.93,105.93 128.12,105.93 126.67,107.38 126.67,111.36 101.3,136.73 101.3,161.42 92.03,170.69 92.02,170.69 90.56,172.15 90.56,178.59 90.69,178.59 90.81,178.7 91.19,178.7 91.69,179.21 91.69,180.74 92.2,181.24 92.2,182.64 92.08,182.77 92.08,185.05 93.34,186.32 93.34,188.65 97.41,192.72 104.32,192.72 105.54,193.94 164.27,193.94 173.23,202.91 177.34,202.91 179.1,204.66 179.1,210.45 182.53,213.88 197.1,213.88 v2(203.71,220.49)
PRSNT#: length 36.1
  TOP w0.127: J5.A1 v2(217.96,240.02) ; R595.1 v2(204.96,223.14)
  L03_SIG1 w0.127: v2(204.96,223.14) 204.96,228.76 202.49,231.23 202.49,233.26 202.63,233.4 202.63,234.89 202.46,235.06 202.46,237.99 203.11,238.64 216.57,238.64 v2(217.96,240.02)
  BOTTOM w0.127: R594.1 216.96,240.02 v2(217.96,240.02)
PWRON_RSTZ: length 81.1
  TOP w0.127: D7.1 108.27,239.08 108.49,239.3 SW5.2 SW5.1 ; D7.1 109.03,238.01 109.3,238.28 R224.1 ; D7.1 107.57,238.01 102.45,232.89 102.45,219.31 95.63,212.49 95.63,204.28 93.09,201.74 J9.1 ; U20.D8 73.93,198.63 v1(74.04,198.52)
  L03_SIG1 w0.102: v1(74.04,198.52) 74.45,198.11 74.66,198.11 74.66,198.11 76.25,198.11 76.89,197.47 77.44,197.47 78.17,198.2 79.2,198.2 80.14,199.14 80.9,199.14
  L03_SIG1 w0.127: 80.9,199.14 81.53,199.14 81.8,198.87 82.3,198.87 83.41,197.75 91.06,197.75 91.69,197.12 J9.1
QSPI_RSTN: length 317.7
  TOP w0.127: U71.1 188.92,73.89 v2(188.82,73.8) ; R273.1 v2(86.49,174.64) 86.74,174.39 88.25,174.39 88.92,173.72 U35.21
  L03_SIG1 w0.127: v2(76.68,59.91) 76.68,63.81 78.66,65.79 80.09,65.79 82.21,63.67 82.21,29.89 86.51,25.59 111.28,25.59 118.41,32.73 118.41,34.75 122.31,38.65 138.15,38.65 140,40.5 140,50.38 148.72,59.1 164.4,59.1 167.18,61.88 167.18,65.42 169.69,67.93 182.96,67.93 v2(188.82,73.8)
  BOTTOM w0.127: v2(86.49,174.64) 85.57,173.73 85.57,163.06 64.48,141.97 64.48,124.81 74.68,114.61 74.68,61.91 v2(76.68,59.91)
QSPI_RSTN_AND: length 2.9
  TOP w0.127: U71.4 192.26,77.46 192.53,77.74 U72.3
RS232_CONN0_RX: length 23.4
  TOP w0.127: U93.13 22,127.07 P1.2
RS232_CONN0_TX: length 24.1
  TOP w0.127: U93.14 23.5,125.8 P1.3
RS232_RX: length 17.6
  TOP w0.127: U13.8 23.51,230.89 22.35,232.04 22.35,239.03 20.9,240.48 J6.4
RS232_TX: length 22.7
  TOP w0.127: U13.13 26.11,225.11 25.4,225.82 22.23,225.82 21.34,226.71 21.34,235.98 19.38,237.94 J6.3
RSV6_TOGGLE: length 216
  TOP w0.127: U33.21 60.98,175.61 60.54,176.05 60.54,176.5 64.01,179.97 66.04,179.97 67.18,178.83 67.18,171.59 74.93,163.84 93.86,163.84 109.6,179.58 109.6,187.53 110.77,188.7 110.77,199.04 109.25,200.56 109.25,204.98 116.98,212.71 122.07,212.71 137.29,197.5 146.46,197.5 161.58,182.38 161.58,179.17 170.81,169.94 v2(171.83,169.94)
  L03_SIG1 w0.127: v2(175.39,146.83) 174.84,147.37 174.84,165.41 173.99,166.26 173.99,169.94 173.66,170.27 172.16,170.27 v2(171.83,169.94)
  BOTTOM w0.127: R927.2 177.55,139.96 177.06,140.45 176.95,140.45 176.35,141.05 176.35,144.46 175.39,145.43 v2(175.39,146.83)
RTC_XI: length 15.1
  TOP w0.127: U17.J19 249.06,52.05 250.67,53.66 250.67,55.44 251.36,56.12 256.53,56.12 257.76,54.89 C52.1 257.82,54.79 258.29,54.31 Y1.2
RTC_XO: length 14.9
  TOP w0.127: U17.H19 248.84,52.85 249.91,53.91 249.91,55.95 251.1,57.14 256.06,57.14 256.61,56.59 C53.1 258.31,56.59 258.53,56.81 Y1.1
RTCK/GP8[0]: length 17.4
  TOP w0.127: R141.2 v2(261.5,50.61) ; U17.K17 v1(247.02,51.65)
  L08_SIG2 w0.102: v1(247.02,51.65) 247.97,52.59 250.98,52.59
  L08_SIG2 w0.127: 250.98,52.59 254.36,52.59 254.91,52.03 257.15,52.03 257.56,51.63 257.56,51.58 258.04,51.09 261.02,51.09 v2(261.5,50.61)
SD_LP2996A: length 192.9
  TOP w0.127: R311.1 v2(121.27,210.85) ; v1(179.61,106.87) 180.01,107.27 U1.E25
  L03_SIG1 w0.102: v1(179.61,106.87) 177.7,104.97
  L03_SIG1 w0.127: 177.7,104.97 173,104.97 172.87,104.84 172.61,104.58 172.61,104.58 172.52,104.49 172.52,103.92 171.84,103.24 168.34,103.24 163.89,98.8 163.12,98.8 162.28,97.96 v2(159.55,97.96)
  L08_SIG2 w0.127: v2(159.55,97.96) 155.83,97.96 155.1,98.69 143.43,98.69 141,101.13 128.27,101.13 125.63,103.77 117.5,103.77 114.17,107.1 114.17,118.63 113.16,119.65 113.16,126.13 115.57,128.54 115.95,128.54 118.62,131.21 118.62,181.88 116.08,184.42 115.29,184.42 v2(114.71,185)
  BOTTOM w0.127: v2(114.71,185) 114.17,185.54 114.17,187.21 113.79,187.59 113.79,209.69 114.55,210.45 120.87,210.45 v2(121.27,210.85)
SEC_REFN: length 3.5
  TOP w0.127: R493.2 137.03,86.25 137.46,86.67 U62.12
SEC_REFP: length 5.4
  TOP w0.127: R496.2 135.51,86.5 136.18,87.17 U62.11
SEL_HDMIN: length 185.4
  TOP w0.102: U81.A4 U81.A3 ; 138.45,64.92 138.69,64.92 138.79,64.82 138.79,63.65 v1(138.45,63.32)
  TOP w0.127: U81.H3 v1(158.25,65.31) ; U82.H4 v1(132.85,63.32) ; SW13.2 142.92,45.73 144.39,47.2 144.39,50.48 v2(144.37,50.49) 144.37,51.37 R520.1 ; U82.A4 v1(138.45,63.32) ; U51.16 97.34,111.57 v2(98.32,112.56) ; U81.H4 v1(158.25,63.71) ; U81.A3 v1(163.85,65.31) ; 138.45,64.92 U82.A3
  L03_SIG1 w0.127: v1(132.85,63.32) 133.25,63.71 133.25,67.15 133.63,67.53 133.63,69.1 133.02,69.71 114.86,69.71 103.86,58.71 103.86,56 98.81,50.94 97.64,50.94 v2(97.51,51.07) ; v1(163.85,65.31) 163.28,64.74 158.88,64.74 158.31,65.31 v1(158.25,65.31) v1(158.25,63.71)
  BOTTOM w0.102: 157.13,63.32 148.29,63.32 ; v1(138.45,63.32) 138.04,62.91 133.27,62.91 v1(132.85,63.32)
  BOTTOM w0.127: 157.13,63.32 157.52,63.71 v1(158.25,63.71) ; 148.29,63.32 v1(138.45,63.32) 144.39,57.38 R520.1 144.37,51.37 v2(144.37,50.49) ; v2(97.51,51.07) 97.03,51.55 97.03,55.01 96.01,56.02 96.01,60.47 97.03,61.48 97.03,74.97 95.45,76.55 95.45,91.63 96.11,92.29 96.11,101.36 98.3,103.55 98.3,112.09 98.32,112.12 v2(98.32,112.56)
SEL_HDMIN_GPIO: length 116.4
  TOP w0.127: U1.G22 v1(178.01,111.41)
  L03_SIG1 w0.127: v2(192.55,68.46) 191.29,67.2 169.35,67.2 167.46,65.31 167.46,61.76 164.42,58.71 151.3,58.71 v2(143.09,50.51)
  L08_SIG2 w0.102: v1(178.01,111.41) 178.41,111.01 179.76,111.01 180.04,110.73 180.04,110.48 181.03,109.49 183.85,109.49 185.27,108.07 185.27,104.62 185.86,104.03
  L08_SIG2 w0.127: 185.86,104.03 186.56,103.33 188.57,103.33 189.45,104.21 190.58,104.21 191.14,103.64 191.14,101.16 191.64,100.65 191.64,98.24 191.44,98.04 191.44,91.61 192.3,90.74 192.3,89.25 193.5,88.05 193.5,78.37 193.34,78.22 193.34,69.26 v2(192.55,68.46)
  BOTTOM w0.127: R521.2 v2(143.09,50.51)
SEL_LCD: length 139.6
  TOP w0.127: v2(134.05,44.76) R809.1 SW14.2 ; U80.2 v2(108.08,19.47)
  L03_SIG1 w0.127: v2(49.48,68.23) 49.48,67.02 53.11,63.39 53.11,47.97 77.95,23.13 101.35,23.13 104.69,19.79 107.76,19.79 v2(108.08,19.47)
  BOTTOM w0.127: v2(134.05,44.76) R809.1 133.94,45.73 133.45,46.22 133.45,46.32 133.2,46.57 127,46.57 117.4,36.97 117.4,32.37 108.08,23.05 v2(108.08,19.47) ; v2(49.48,68.23) R728.1
SEL_LCDN: length 246.4
  TOP w0.102: U81.J4 U81.J3 ; U81.T4 U81.T3
  TOP w0.127: v2(128.4,45.71) 118.14,35.45 118.14,29 112.57,23.43 112.57,19.06 112.33,18.82 U80.4 ; R471.2 v2(50.46,67.12) ; U82.J3 v1(131.25,64.92) ; U82.J4 v1(131.25,63.32) ; U81.T3 v1(151.05,65.31) ; v2(97.56,112.56) 97.07,112.07 U51.17 ; U82.H3 v1(132.85,64.92) ; U81.J3 v1(156.65,65.31)
  L03_SIG1 w0.127: v1(132.85,64.92) v1(131.25,64.92) v1(131.25,63.32) 131.25,63.07 132.89,61.44 132.89,50.2 v2(128.4,45.71) ; v1(156.65,65.31) 155.88,64.53 151.83,64.53 v1(151.05,65.31)
  L08_SIG2 w0.127: v1(131.25,64.92) 130.85,65.32 128.65,65.32 128.59,65.38 124.02,65.38 123.06,66.33 110.01,66.33 108.64,64.96 v2(95.02,64.96)
  BOTTOM w0.127: v1(151.05,65.31) 151.04,65.32 133.26,65.32 v1(132.85,64.92) ; v2(97.56,112.56) 97.1,112.11 97.1,104.84 95.25,102.99 95.25,92.95 94.67,92.37 94.67,65.32 v2(95.02,64.96) 95.02,53.63 90.3,48.91 62.61,48.91 54.1,57.42 54.1,63.48 v2(50.46,67.12)
SEL_LCDN_GPIO: length 175.2
  TOP w0.127: U1.B14 182.81,118.61 187.69,118.61 189.99,116.31 v2(189.99,115.84)
  BOTTOM w0.127: R807.2 135.35,46.84 136.75,48.24 136.75,53.94 133.91,56.78 128.52,56.78 123.32,61.99 123.32,66.56 128.63,71.87 151.43,71.87 153.57,74.01 153.57,84.01 154.61,85.05 156.39,85.05 167.32,74.12 175.96,74.12 177.27,75.43 178.54,75.43 187.02,83.91 193.15,83.91 194.11,84.87 194.11,95.65 194.94,96.48 194.94,97.68 190.88,101.74 189.65,101.74 188.47,102.93 186.96,102.93 185.27,104.61 185.27,106.45 186.61,107.79 186.61,112.79 185.24,114.16 185.24,115.36 185.8,115.92 189.92,115.92 v2(189.99,115.84)
SEL_XDS: length 75.5
  TOP w0.127: U133.1 227.3,95.3 v2(225.93,96.66) 225.3,97.3 U41.22 ; v2(232.82,114.29) 232.79,114.26 225.88,114.26 223.93,112.31 223.93,111.65 223.46,111.18 U134.1 ; U47.4 v2(212.87,93.74)
  L03_SIG1 w0.127: v2(225.93,96.66) 217.32,96.66 214.4,93.74 v2(212.87,93.74)
  L08_SIG2 w0.127: v2(215.82,83.2) 216.55,83.92 216.55,84.1 217.04,84.6 217.04,85.74 216.41,86.37 216.41,88.23 215.53,89.11 214.5,89.11 212.87,90.74 v2(212.87,93.74) ; v2(225.93,96.66) 232.64,103.37 232.64,108.5 230.35,110.78 230.35,111.9 232.74,114.29 v2(232.82,114.29)
  BOTTOM w0.127: U37.15 218.11,80.58 218.34,80.81 218.34,81.37 218.01,81.7 216.08,81.7 215.72,82.06 215.72,83.1 v2(215.82,83.2)
SEL_XDS200_INV: length 36.3
  TOP w0.127: R391.1 211.18,70.91 v2(211.18,72.88) J19.58 ; U132.22 218.85,92.72 218.86,92.74 218.86,93.12 218.37,93.61 217.3,93.61 217.3,93.68 v2(217.36,93.68) ; U47.2 v2(212.22,88.79)
  L08_SIG2 w0.127: v2(212.22,88.79) 212.22,85.49 213.72,83.99 213.72,81.78 212.47,80.53 212.47,74.17 v2(211.18,72.88)
  BOTTOM w0.127: v2(217.36,93.68) 216.18,92.5 212.39,92.5 211.57,91.67 R717.2 211.57,88.99 211.77,88.79 v2(212.22,88.79)
SOC_ARM_BENDIAN: length 207.4
  TOP w0.102: U20.J18 78.94,196.74 79.2,196.74 79.22,196.71 79.91,196.71 v1(79.93,196.69)
  L08_SIG2 w0.127: v2(177.57,81.29) 178.13,81.85 178.13,82.36 177.85,82.64 176.23,82.64 174.04,84.83 167.54,84.83 167.44,84.93 166.83,84.93 166.73,84.83 165.84,84.83 164.48,86.18 164.02,86.18 164.01,86.2 163.8,86.2 163.79,86.18 155.64,86.18 154.97,86.86 136.86,86.86 135.03,88.69 115.54,88.69 112.99,91.24 112.99,91.99 108.49,96.49 108.49,96.59 107.73,97.34 107.73,131.33 96.05,143.01 78.12,160.94 78.12,161.14 77.96,161.3 77.96,187.47 79.76,189.27 79.76,190.51 79.58,190.69 79.58,192.06 80.8,193.28 80.8,194.5 80.04,195.26 80.04,196.59 v1(79.93,196.69)
  BOTTOM w0.127: U66.9 178.74,90.69 181.29,88.14 181.29,85.06 180.86,84.63 179.68,84.63 177.71,82.67 177.53,82.67 177.11,82.25 177.11,81.75 v2(177.57,81.29)
SOC_ARM_LENDIAN: length 199.3
  TOP w0.102: v2(79.02,190.54) 79.02,190.59 79.78,191.35 79.78,192.6 79.65,192.73 U20.U19
  L08_SIG2 w0.127: v2(177.57,82.06) 176.45,82.06 173.94,84.57 167.44,84.57 167.34,84.67 166.93,84.67 166.83,84.57 165.28,84.57 163.91,85.94 155.52,85.94 154.86,86.6 136.75,86.6 134.92,88.43 115.44,88.43 112.75,91.12 112.75,91.89 107.49,97.14 107.49,131.23 95.81,142.91 77.88,160.84 77.88,161.04 77.65,161.27 77.65,188.25 78.19,188.8 78.19,189.71 v2(79.02,190.54)
  BOTTOM w0.127: v2(177.57,82.06) 179.87,84.35 180.98,84.35 181.57,84.95 181.57,88.25 179.14,90.69 U66.8
SOC_BACKLIGHT_PWM: length 178.7
  TOP w0.127: v2(69.14,94.2) 48.87,94.2 38.88,84.21 Q12.1 37.76,80.12 37.71,80.06 R429.2 ; U1.E18 v1(179.61,114.61)
  L03_SIG1 w0.102: v1(179.61,114.61) 179.2,115.03 179.2,115.55 179.19,115.55 179.19,115.57 178.95,115.81 178.61,115.81 178.41,116.02 178.41,116.4 178.19,116.61 170.96,116.61 170.41,116.07 170.41,110.48 170.39,110.46 170.39,110.46 170.17,110.23 170.16,110.23 169.95,110.02 166.59,110.02 165.63,109.06 164.82,109.06 163.22,107.46 161.51,107.46 161.21,107.75
  L03_SIG1 w0.127: v2(69.14,94.2) 70.02,93.32 108.64,93.32 112.97,88.99 131.78,88.99 133.96,86.8 147.28,86.8 150.01,89.54 150.01,92.25 150.08,92.32 150.08,100.75 154.75,105.42 154.75,105.73 155.23,106.21 156.5,106.21 158.52,108.23 160.73,108.23 161.21,107.75
SOC_BOOTCOMPLETE: length 193.2
  TOP w0.102: 76.31,202.55 76.31,202.33 76.12,202.13 76.12,200.63 76.43,200.32 U20.B13
  TOP w0.127: R379.2 v2(166.75,142.85) ; U1.Y3 v1(168.41,127.41) ; v1(75.74,204.21) 75.74,203.62 76.31,203.05 76.31,202.55
  L03_SIG1 w0.102: 168.53,134.89 168.53,127.53 v1(168.41,127.41)
  L03_SIG1 w0.127: 168.53,134.89 168.53,134.99 167.54,135.98 166.73,135.98 166.23,136.48 166.23,142.33 v2(166.75,142.85)
  L08_SIG2 w0.102: 165.61,134.89 165.61,134.84 164.69,133.92 164.69,131.92 168.41,128.2 v1(168.41,127.41)
  L08_SIG2 w0.127: v1(75.74,204.21) 75.92,204.38 79.96,204.38 83.44,200.9 84.68,200.9 85.6,199.99 86.07,199.99 86.08,199.98 86.95,199.98 88.52,198.41 88.52,197.18 89.15,196.54 89.15,193.79 89.26,193.69 89.26,190.19 88.67,189.61 88.67,185.18 89.33,184.52 100.34,184.52 102.23,182.63 104.71,182.63 105.44,183.35 105.44,185.46 110.26,190.29 153.6,190.29 160.88,183 160.88,170.19 161.14,169.94 161.14,155.72 161.65,155.21 161.65,153.28 161.06,152.69 161.06,150.04 161.49,149.61 161.49,148.67 161.01,148.19 161.01,145.42 161.37,145.06 161.37,139.64 165.61,135.4 165.61,134.89
SOC_CPTS_TS_COMP: length 39.2
  TOP w0.127: U1.C21 v1(182.01,113.01) ; v2(203.33,130.2) 203.21,130.09 R816.2
  L08_SIG2 w0.102: v1(182.01,113.01) 183.67,113.01 184.07,112.61 187.05,112.61 187.85,113.41 189.1,113.41
  L08_SIG2 w0.127: 189.1,113.41 190.51,113.41 191.21,112.71 194.04,112.71 194.14,112.82 v2(194.39,112.82)
  BOTTOM w0.127: v2(194.39,112.82) 198.32,112.82 199.29,113.78 200.38,113.78 201.12,114.52 201.12,119.04 202.74,120.66 202.74,124.02 202.49,124.27 202.49,128.28 203.4,129.2 203.4,130.13 v2(203.33,130.2)
SOC_DCAN0_RX: length 238.2
  TOP w0.102: C314.1 J26.2 R545.1
  TOP w0.127: U1.R5 v1(171.61,125.01)
  L03_SIG1 w0.102: J26.2 45.9,189.02 45.9,179.62 44.3,178.02 44.3,169.66 50.55,163.41 50.55,132.53 83.65,99.43 95.17,99.43 96.49,98.11 111.28,98.11 111.84,98.67 113.79,98.67 113.87,98.59 v2(114.3,98.59)
  L08_SIG2 w0.102: v2(114.3,98.59) 129.44,98.59 130.48,97.55 137.49,97.55 138.28,98.34 140.87,98.34 142.48,96.73 147.05,96.73 147.83,95.96 151.85,95.96 153.11,97.22 159.76,97.22 160.06,97.52 160.06,98.48 161.14,99.56 161.76,99.56 165.39,103.19 166.12,103.19 166.33,102.99 167.02,102.99 167.29,103.26 167.29,105.84 167.72,106.27 167.72,107.16 167.84,107.29 167.84,107.29 168.32,107.76 168.57,107.76 168.79,107.99 168.79,109.21 168.23,109.77 168.23,110.01 168.23,110.17 168.03,110.37 168.03,111.57 168.25,111.8 168.28,111.8 168.28,111.8 168.62,111.8 169.63,112.81 169.63,114.01 169.65,114.03 169.65,114.04 169.85,114.24 169.85,114.23 170.2,114.23 170.43,114.46 170.43,114.77 170.65,114.99 170.66,114.99 170.69,115.03 171.76,115.03 172.02,115.29 172.02,124.6 v1(171.61,125.01)
SOC_DCAN0_TX: length 36.1
  TOP w0.102: U1.P5 v1(173.21,125.81)
  L08_SIG2 w0.102: v2(162.18,99) 162.18,98.95 163.58,100.34 164.32,100.34 166.65,102.68 167.15,102.68 167.6,103.13 167.6,105.71 168.03,106.14 168.03,107.03 168.15,107.16 168.15,107.16 168.44,107.45 168.7,107.45 169.1,107.86 169.1,109.34 168.54,109.9 168.54,110.14 168.79,110.38 168.79,111.53 169.29,112.03 169.67,112.03 170.44,112.8 170.43,112.81 170.43,113.97 170.65,114.19 172.57,114.19 172.83,114.45 172.83,123.8 173.61,124.58 173.61,125.41 v1(173.21,125.81)
  BOTTOM w0.102: v2(162.18,99) 162.47,99.29 R544.1
SOC_DCAN1_RX: length 235.4
  TOP w0.102: U1.H21 v1(177.21,112.21)
  TOP w0.127: R540.1 J25.2 C313.1
  L03_SIG1 w0.102: 163.94,104.03 164.39,104.47 164.39,105.86 164.97,106.44 167.03,106.44 168.21,107.62 171.67,107.62 173.18,109.13 175.03,109.13 175.21,109.31 175.21,112.36 175.46,112.61 176,112.61 176.4,112.21 v1(177.21,112.21)
  L03_SIG1 w0.127: J25.2 45.62,159.02 45.62,147.74 38.1,140.22 38.1,134.08 38.09,134.06 38.09,107.78 43.92,101.95 44.18,101.95 45.35,101.95 59.48,87.81 109.72,87.81 110.04,87.48 112.34,87.48 128.92,87.48 133.4,83 133.42,83 133.5,82.92 148.44,82.92 153.84,88.32 153.84,93.12 154.63,93.91 154.63,99.57 153.8,100.4 153.8,100.9 154.89,102 161.91,102 163.94,104.03
SOC_DCAN1_TX: length 29.5
  TOP w0.102: v1(177.21,111.41) U1.H22
  L03_SIG1 w0.102: v1(177.21,111.41) 177.6,111.03 177.6,110.38 176.12,108.9 173.39,108.9 171.8,107.31 171.54,107.31 168.26,107.31 167.08,106.14 165.1,106.14 164.64,105.68 164.64,104.33 164.34,104.03
  L03_SIG1 w0.127: 164.34,104.03 161.72,101.41 155.32,101.41 v2(155.27,101.46)
  BOTTOM w0.127: R539.1 154.77,101.09 155.14,101.46 v2(155.27,101.46)
SOC_DSS_DE: length 24.8
  TOP w0.127: R512.2 162.56,96.53 162.18,96.15 v2(161.72,96.15) ; U1.M25 174.41,107.27 v1(174.81,106.87)
  BOTTOM w0.102: 171.17,104.03 171.17,105.76 171.45,106.03 173.08,106.03 173.92,106.87 v1(174.81,106.87)
  BOTTOM w0.127: 171.17,104.03 171.17,103.49 170.63,102.95 167.83,102.95 166.57,101.69 166.57,101.39 165.64,100.45 165.64,98.86 165.65,98.85 165.64,98.83 165.64,97.07 164.72,96.15 v2(161.72,96.15)
SOC_DSS_FID: length 10.6
  TOP w0.127: v2(174.9,101.11) 174.65,101.36 174.44,101.36 174.17,101.63 174.17,106.06 174.45,106.34 175,106.34 175.28,106.62 175.28,108.53 175.21,108.6 U1.L25
  BOTTOM w0.127: TP157.1 175.18,101.39 v2(174.9,101.11)
SOC_DSSDATA0: length 19.6
  TOP w0.127: v2(176.43,103.57) 176.66,103.34 176.66,100.34 176.05,99.74 v2(176.02,99.74) ; U1.V22 v1(169.21,111.41)
  BOTTOM w0.127: v2(176.02,99.74) 176.28,99.48 176.28,98.78 RA10.1 ; v1(169.21,111.41) 169.6,111.02 169.6,110.07 170.75,108.92 175.07,108.92 176.86,107.13 176.86,104 v2(176.43,103.57)
SOC_DSSDATA1: length 20.2
  TOP w0.127: U1.U21 v1(170.81,113.01)
  L08_SIG2 w0.102: v1(170.81,113.01) 171.22,113.43 172.54,113.43 172.8,113.17 172.8,110.34 172.21,109.75 172.21,106.31 172.22,106.29 172.22,106.25 172.45,106.02 172.45,104.03
  L08_SIG2 w0.127: v2(175.74,100.42) 175.61,100.55 174.78,100.55 174.44,100.89 174.44,101.69 172.45,103.67 172.45,104.03
  BOTTOM w0.127: RA10.2 176.91,99.7 176.19,100.42 v2(175.74,100.42)
SOC_DSSDATA2: length 20
  TOP w0.127: U1.W22 v1(168.41,111.41)
  BOTTOM w0.127: v1(168.41,111.41) 168.82,111.01 168.82,109.96 169.26,109.52 169.26,107.83 169.75,107.34 174.95,107.34 175.27,107.03 175.27,103.08 176.86,101.49 176.86,100.14 177.42,99.58 RA10.3
SOC_DSSDATA3: length 24.8
  TOP w0.127: U1.V23 v1(169.21,110.61)
  BOTTOM w0.127: U66.4 178.74,94.8 178.94,95 178.94,98.59 178.77,98.77 RA10.4 178.07,99.33 177.14,100.26 177.14,101.65 175.55,103.25 175.55,107.14 175.04,107.65 169.86,107.65 169.54,107.96 169.54,109.62 169.19,109.97 169.19,110.59 v1(169.21,110.61)
SOC_DSSDATA4: length 17.6
  TOP w0.127: v2(178.69,102.53) 179.18,102.03 179.18,101.84 179.46,101.56 RA7.1 ; U1.U23 v1(170.01,110.61)
  BOTTOM w0.127: v1(170.01,110.61) 170.01,110.17 170.94,109.24 176.02,109.24 176.83,108.42 176.83,107.53 177.14,107.23 177.14,102.91 177.52,102.53 v2(178.69,102.53)
SOC_DSSDATA5: length 25.4
  TOP w0.127: U1.V24 170.01,109.81 v1(170.01,108.14) ; v2(178.69,101.82) 178.82,101.69 RA7.2
  BOTTOM w0.102: 175.67,107.86 175.82,107.71 175.82,104.14
  BOTTOM w0.127: U66.5 179.14,94.63 179.22,94.71 179.22,99.33 178.69,99.86 v2(178.69,101.82) 178.24,101.82 178.18,101.75 177.43,101.75 175.82,103.36 175.82,104.14 ; 175.67,107.86 175.67,107.92 174.95,108.64 170.5,108.64 v1(170.01,108.14)
SOC_DSSDATA6: length 24.5
  TOP w0.127: v2(179.73,102.01) 179.15,102.59 179.15,102.72 178.78,103.09 178.46,103.09 178.1,102.73 178.1,101.69 178.31,101.49 RA7.3 ; U1.T21 v1(171.61,113.01)
  BOTTOM w0.127: RA17.2 180.47,101.84 180.3,102.01 v2(179.73,102.01) 180.23,102.5 180.23,102.95 179.55,103.62 178.82,103.62 178.54,103.9 178.54,107.29 178.3,107.52 177.75,107.52 177.32,107.96 177.32,108.83 176.28,109.87 173.18,109.87 172.85,110.2 172.85,113.25 172.67,113.42 172.02,113.42 v1(171.61,113.01)
SOC_DSSDATA7: length 23.2
  TOP w0.127: U1.U22 v1(170.01,111.41) ; RA7.4 177.66,102.82 178.21,103.37 179.04,103.37 179.67,102.75 v2(179.73,102.75)
  BOTTOM w0.127: v1(170.01,111.41) 170.42,111.01 170.42,110.27 171.13,109.55 176.09,109.55 177.06,108.57 177.06,107.69 177.42,107.33 177.42,103.65 177.8,103.27 179.21,103.27 v2(179.73,102.75) 179.24,102.25 179.24,101.75 179.81,101.18 RA17.1
SOC_DSSDATA8: length 25.4
  TOP w0.127: U1.T22 v1(170.81,111.41) ; v2(166.22,96.36) 166.22,95.55 166.41,95.35 U67.23
  L08_SIG2 w0.102: v1(170.81,111.41) 170.58,111.41 170.18,111.01 169.87,111.01 169.63,110.77 169.63,110 169.34,109.72 169.34,105.73 168.76,105.15 168.76,104.03
  L08_SIG2 w0.127: 168.76,104.03 168.76,103.88 170.18,102.46 170.18,99.84 167.73,97.39 167.03,97.39 166.59,96.94 166.59,96.94 166.22,96.57 v2(166.22,96.36)
  BOTTOM w0.127: RA9.1 166.26,95.53 166.22,95.57 v2(166.22,96.36) 166.22,96.8 166.11,96.92 RA19.8
SOC_DSSDATA9: length 27.1
  TOP w0.127: U1.R21 v1(172.41,113.01) ; v2(166.83,95.82) 166.83,95.38 166.81,95.36 U67.22
  L08_SIG2 w0.102: 169.57,104.03 169.57,104.97 169.54,104.99 169.54,109.12 170.39,109.97 170.39,110.73 170.67,111.01 170.99,111.01 171.2,111.22 171.2,111.8 v1(172.41,113.01)
  L08_SIG2 w0.127: 169.57,104.03 170.46,103.14 170.46,99.13 168.63,97.3 168.63,97.27 168.5,97.14 167.13,97.14 166.83,96.84 v2(166.83,95.82)
  BOTTOM w0.127: RA9.2 166.82,95.27 166.83,95.28 v2(166.83,95.82) 166.83,96.27 166.67,96.43 RA19.7
SOC_DSSDATA10: length 21.2
  TOP w0.127: U1.U24 170.81,109.81 170.81,105.13 170.95,104.99 170.95,100.45 170.54,100.04 170.54,98.63 168.55,96.65 v2(168.55,96.56) 168.55,95.4 168.81,95.14 U67.17
  BOTTOM w0.127: RA19.4 168.17,97.1 168.55,96.71 v2(168.55,96.56) 168.55,95.72 168.32,95.49 RA9.5
SOC_DSSDATA11: length 20.6
  TOP w0.127: U1.V25 169.61,105.39 170.4,104.59 170.4,100.75 169.88,100.22 169.88,99.13 v2(167.34,96.59) 167.34,95.65 167.61,95.37 U67.20
  BOTTOM w0.127: RA9.3 167.32,96.57 v2(167.34,96.59) 167.34,96.94 167.17,97.11 RA19.6
SOC_DSSDATA12: length 21.5
  TOP w0.127: v1(171.61,108.14) 171.61,109.81 U1.T24 ; U67.13 170.41,95.75 v2(170.43,95.77)
  L08_SIG2 w0.102: v1(171.61,108.14) 171.18,107.71 171.18,104.05 171.2,104.03
  L08_SIG2 w0.127: v2(170.43,95.77) 170.43,96.69 172.02,98.28 172.02,100.01 172.03,100.03 172.03,100.32 171.37,100.98 171.37,103.85 171.2,104.03
  BOTTOM w0.127: RA19.1 169.73,97.28 169.75,97.28 170.43,96.6 v2(170.43,95.77) 170.43,95.6 169.89,95.05 RA9.8
SOC_DSSDATA13: length 24.5
  TOP w0.127: U67.14 170.01,95.32 169.98,95.35 v2(169.98,96.41) ; U1.P21 v1(172.41,112.21)
  L08_SIG2 w0.102: 170.92,104.03 170.92,104.14 170.92,108.46 171.58,109.13 171.58,109.99 ; v1(172.41,112.21) 172.02,111.83 172.02,110.43
  L08_SIG2 w0.127: 170.92,104.03 170.92,103.67 171.04,103.55 171.04,100.9 171.73,100.22 171.73,98.54 169.98,96.79 v2(169.98,96.41) ; 172.02,110.43 171.58,109.99
  BOTTOM w0.127: RA19.2 169.17,97.22 v2(169.98,96.41) 169.98,95.82 169.32,95.17 RA9.7
SOC_DSSDATA14: length 20.3
  TOP w0.127: U67.19 168.01,95.86 v2(168,95.88) 168,96.71 170.26,98.97 170.26,100.19 170.67,100.61 170.67,104.83 170.41,105.09 U1.U25
  BOTTOM w0.127: RA9.4 167.82,95.7 v2(168,95.88) 168,96.66 167.67,96.99 RA19.5
SOC_DSSDATA15: length 22.9
  TOP w0.127: U1.R22 v1(171.61,111.41) ; v2(169.21,95.93) U67.16
  L08_SIG2 w0.102: v1(171.61,111.41) 171.61,111.16 171.22,110.77 171.22,109.13 170.56,108.47 170.56,104.03
  L08_SIG2 w0.127: v2(169.21,95.93) 169.21,96.81 170.74,98.34 170.74,103.34 170.56,103.52 170.56,104.03
  BOTTOM w0.127: RA9.6 168.82,95.54 v2(169.21,95.93) 169.21,96.7 168.67,97.25 168.67,97.79 RA19.3
SOC_DSSDATA16: length 21.7
  TOP w0.127: U1.P23 v1(172.41,110.61) ; v2(172.8,95.95) 172.8,95.75 172.41,95.36 U67.8
  L08_SIG2 w0.102: 172.16,104.03 172.16,106.02 172.06,106.12 172.06,106.13 172.02,106.17 172.02,106.21 172.01,106.22 172.01,109.84 172.41,110.24 v1(172.41,110.61)
  L08_SIG2 w0.127: v2(172.8,95.95) 172.8,95.95 172.8,97.4 173.28,97.88 173.28,100.62 172.72,101.18 172.72,102.07 172.16,102.63 172.16,104.03
  BOTTOM w0.127: RA18.5 v2(172.8,95.95) 172.8,95.32 172.65,95.17 RA8.4
SOC_DSSDATA17: length 20.4
  TOP w0.127: U1.R24 172.42,109.81 172.42,101.3 171.99,100.88 171.97,100.88 171.97,97.13 171.8,96.96 v2(171.8,95.98) 171.21,95.39 U67.11
  BOTTOM w0.127: RA8.2 171.65,95.49 171.8,95.64 v2(171.8,95.98) RA18.7
SOC_DSSDATA18: length 26
  TOP w0.127: U1.N22 v1(174.01,112.21) ; v2(174.3,96.51) 174.3,95.65 174.41,95.53 U67.3
  L08_SIG2 w0.102: v1(174.01,112.21) 174.42,111.8 174.42,111.19 174.24,111.01 173.87,111.01 173.51,110.65 173.51,108.86 175.54,106.82 175.54,104.41 175.92,104.03
  L08_SIG2 w0.127: v2(174.3,96.51) 174.47,96.69 174.98,96.69 177.04,98.74 177.04,101.72 175.92,102.83 175.92,104.03 175.92,104.03
  BOTTOM w0.127: RA8.7 174.15,94.94 174.35,95.14 174.35,96.47 v2(174.3,96.51) RA18.2
SOC_DSSDATA19: length 20.1
  TOP w0.127: U67.12 170.81,95.39 171.07,95.65 v2(171.07,96.56) 171.07,97.22 171.69,97.85 171.69,100.23 171.23,100.69 171.23,101.94 172.06,102.77 172.06,104.54 171.21,105.39 U1.T25
  BOTTOM w0.127: RA8.1 171.08,95.92 171.07,95.93 v2(171.07,96.56) 171.07,97 171.24,97.17 RA18.8
SOC_DSSDATA20: length 20.3
  TOP w0.127: U1.N24 174.01,109.81 174.01,107.15 173.86,107.01 173.86,103.89 173.89,103.86 173.89,101.44 174.27,101.06 174.27,99.03 174.86,98.44 v2(174.86,95.96) 174.81,95.91 U67.2
  BOTTOM w0.127: RA18.1 v2(174.86,95.96) 174.83,95.93 174.83,95.21 174.71,95.1 RA8.8
SOC_DSSDATA21: length 23.2
  TOP w0.127: v2(173.8,96) 173.8,95.48 173.61,95.29 U67.5 ; U1.P24 173.21,109.81 v1(173.21,108.14)
  L08_SIG2 w0.102: v1(173.21,108.14) 173.21,107.86 175.26,105.81 175.26,104.29 175.53,104.03
  L08_SIG2 w0.127: v2(173.8,96) 173.8,96.9 174.09,97.2 174.9,97.2 176.78,99.07 176.78,101.58 175.64,102.72 175.64,103.91 175.53,104.03
  BOTTOM w0.127: RA8.6 173.65,95.08 173.86,95.29 173.86,95.94 v2(173.8,96) 173.8,97.76 RA18.3
SOC_DSSDATA22: length 19.8
  TOP w0.127: U67.9 172.01,95.39 172.3,95.68 v2(172.3,96.52) 172.3,98.02 173.48,99.2 173.48,100.44 172.81,101.11 U1.P25
  BOTTOM w0.127: RA18.6 v2(172.3,96.52) 172.3,95.53 172.15,95.38 RA8.3
SOC_DSSDATA23: length 25.4
  TOP w0.102: U1.N23 v1(174.01,111.41)
  TOP w0.127: U67.6 173.21,95.6 173.3,95.69 v2(173.3,96.53)
  L08_SIG2 w0.102: v1(174.01,111.41) 173.86,111.41 173.23,110.78 173.23,110.12 172.82,109.72 172.82,107.84 174.35,106.31 174.35,104.21 174.35,104.2 174.35,104.14 174.47,104.03
  L08_SIG2 w0.127: v2(173.3,96.53) 173.3,96.91 173.94,97.55 174.75,97.55 176.53,99.33 176.53,101.43 175.36,102.6 175.36,103.19 174.67,103.88 174.62,103.88 174.47,104.03
  BOTTOM w0.127: RA18.4 v2(173.3,96.53) 173.3,95.18 173.15,95.03 RA8.5
SOC_DSSHSYNC: length 25.9
  TOP w0.127: U1.P22 v1(172.41,111.41) ; R514.2 159.38,97.04 160.15,97.8 163.19,97.8 v2(163.58,98.19)
  BOTTOM w0.127: v2(163.58,98.19) 163.58,101.36 164.04,101.82 164.04,103.63 165.45,105.04 166.05,105.04 166.41,105.4 166.41,105.82 167.23,106.64 167.23,107.81 168,108.58 168,111.56 168.25,111.81 172.02,111.81 v1(172.41,111.41)
SOC_DSSPCLK: length 19.4
  TOP w0.127: v2(165.03,97.24) 165.03,97.24 165.03,97.24 164.84,97.04 164.84,96.78 164.68,96.63 R513.2 ; U1.N25 173.61,107.27 v1(173.21,106.87)
  BOTTOM w0.102: 170.79,103.97 170.8,103.98 170.8,104.18 170.81,104.19 170.81,105.91 171.36,106.45 172.79,106.45 v1(173.21,106.87)
  BOTTOM w0.127: 170.79,103.97 170.17,103.34 167.99,103.34 167.98,103.33 167.68,103.33 166.19,101.85 166.19,101.55 165.25,100.61 165.25,99.23 165.25,97.46 v2(165.03,97.24)
SOC_DSSVSYNC: length 22.6
  TOP w0.127: v1(171.61,106.87) 172.01,107.27 U1.R25 ; v2(161.67,97.17) 161.42,97.42 161.04,97.42 160.91,97.3 R511.2
  BOTTOM w0.102: 170.43,104.15 170.43,106.11 171.2,106.87 v1(171.61,106.87)
  BOTTOM w0.127: 170.43,104.15 170.01,103.72 167.89,103.72 167.68,103.94 166.33,103.94 165.08,102.68 165.08,101.07 164.87,100.87 164.87,100.77 164.87,97.85 163.82,96.79 162.05,96.79 v2(161.67,97.17)
SOC_ECAP1_IN_PWM1_OUT: length 191.5
  TOP w0.127: U1.D18 v1(181.21,115.41)
  L08_SIG2 w0.102: v1(181.21,115.41) 181.63,114.99 182.35,114.99 183.24,114.11 186.89,114.11 187.15,114.37 189.1,114.37
  L08_SIG2 w0.127: 189.1,114.37 196.33,114.37 197.04,113.65 203.24,113.65 206.62,110.28 208.3,110.28 208.92,109.65 208.92,109.63 209.62,108.93 209.74,108.93 210.01,108.66 210.01,107.38 v2(210.44,106.95)
  BOTTOM w0.127: J12.42 301.25,184.93 299.76,184.93 287.96,173.13 287.96,147.17 269.65,128.86 245.65,128.86 239.23,135.27 222.66,135.27 221.61,134.22 221.61,117.67 219.33,115.38 219.33,111.65 215.26,107.58 211.07,107.58 v2(210.44,106.95)
SOC_EHRPWM3_SYNCI: length 188.4
  TOP w0.127: U1.C22 v1(182.01,112.21)
  L08_SIG2 w0.102: v1(182.01,112.21) 182.41,112.21 182.52,112.11 187.32,112.11 187.62,112.4 188.76,112.4 189.05,112.69 189.1,112.69
  L08_SIG2 w0.127: v2(209.17,107.46) 208.53,108.09 206.68,108.09 204.99,109.78 199.98,109.78 199.4,110.35 199.24,110.52 196.5,110.52 195.41,111.61 193.78,111.61 193.23,112.16 191.01,112.16 190.97,112.19 190.96,112.19 190.46,112.69 189.1,112.69
  BOTTOM w0.127: J12.39 287.12,175.88 287.12,147.51 269.3,129.69 246.24,129.69 239.94,135.99 222.2,135.99 220.78,134.57 220.78,118.83 218.77,116.82 218.77,112.08 214.88,108.19 210.64,108.19 209.91,107.46 v2(209.17,107.46)
SOC_EHRPWM3_SYNCO: length 187.9
  TOP w0.127: U1.D23 v1(181.21,111.41)
  L08_SIG2 w0.102: 189.1,111.34 188.77,111.01 187.53,111.01 187.25,110.73 186.42,110.73 185.76,111.39 182.73,111.39 182.3,110.96 181.66,110.96 v1(181.21,111.41)
  L08_SIG2 w0.127: v2(209.3,106.69) 208.9,107.09 206.74,107.09 205.23,108.6 197.08,108.6 195.07,110.61 193.58,110.61 193.55,110.64 193.55,110.66 192.66,111.55 189.31,111.55 189.1,111.34
  BOTTOM w0.127: J12.41 287.68,173.9 287.68,147.28 269.54,129.14 245.76,129.14 239.39,135.51 222.51,135.51 221.34,134.34 221.34,117.85 219.07,115.58 219.07,111.9 215.09,107.91 210.76,107.91 209.85,107.01 209.61,107.01 v2(209.3,106.69)
SOC_EHRPWM3A: length 197.3
  TOP w0.102: v1(187.02,110.23) 186.99,110.25 185.55,110.25 184.78,111.01
  TOP w0.127: U1.A23 184.78,111.01
  L08_SIG2 w0.102: 189.1,110.63 187.53,110.63 187.12,110.23 v1(187.02,110.23)
  L08_SIG2 w0.127: 189.1,110.63 189.74,111.27 192.18,111.27 193.17,110.28 194.94,110.28 195.43,109.79 195.43,109.13 197.23,107.33 198.88,107.33 199.26,107.71 205.46,107.71 206.42,106.76 208.09,106.76 v2(208.41,106.44)
  BOTTOM w0.127: v2(208.41,106.44) 207.82,107.03 207.82,107.77 208.24,108.19 208.64,108.19 209.03,108.58 209.03,108.75 209.32,109.03 214.53,109.03 217.91,112.4 217.91,117.81 219.79,119.69 219.79,134.76 221.74,136.72 240.74,136.72 246.93,130.53 268.96,130.53 286.28,147.86 286.28,177.46 297.71,188.89 297.71,195.15 298.89,196.33 J12.33
SOC_EHRPWM3B: length 192.5
  TOP w0.127: U1.B22 182.81,112.21 184.9,112.21 185.32,111.8 186.63,111.8 v1(187.02,111.41)
  L08_SIG2 w0.102: 189.1,112.16 187.76,112.16 v1(187.02,111.41)
  L08_SIG2 w0.127: 189.1,112.16 190.6,112.16 190.88,111.88 193.12,111.88 193.76,111.23 195.4,111.23 196.39,110.24 196.62,110.24 199.12,110.24 199.82,109.54 204.88,109.54 206.83,107.58 v2(208.28,107.58)
  BOTTOM w0.127: J12.35 298.45,192.29 298.45,188.1 286.84,176.49 286.84,147.63 269.19,129.97 246.47,129.97 240.21,136.24 222.05,136.24 220.5,134.69 220.5,119.24 218.47,117.2 218.47,112.17 214.77,108.47 210.53,108.47 209.97,107.91 208.61,107.91 v2(208.28,107.58)
SOC_EHRPWM4A: length 173.3
  TOP w0.127: U1.D12 v1(181.21,120.21)
  L08_SIG2 w0.102: 187.78,120.16 188.04,119.9 189.1,119.9 ; 182.83,119.83 181.6,119.83 v1(181.21,120.21)
  L08_SIG2 w0.127: 189.1,119.9 191.52,119.9 192.41,119.01 195.07,119.01 195.58,119.52 196.47,119.52 198.07,121.12 203.48,121.12 203.65,121.29 221.35,121.29 v2(222.12,122.06) ; 182.83,119.83 183.16,120.16 187.78,120.16
  BOTTOM w0.127: J12.45 296.64,181.09 288.24,172.68 288.24,147.05 269.77,128.58 245.53,128.58 239.09,135.02 222.86,135.02 222.12,134.28 v2(222.12,122.06)
SOC_EHRPWM4B: length 173.6
  TOP w0.127: U1.D13 v1(181.21,119.41)
  L08_SIG2 w0.102: 189.1,119.03 181.6,119.03 v1(181.21,119.41)
  L08_SIG2 w0.127: v2(222.38,121.05) 203.75,121.05 202.63,119.93 200.74,119.93 200.51,120.16 197.88,120.16 195.21,117.49 193.69,117.49 193.64,117.54 193.26,117.54 193.21,117.49 192.53,117.49 190.89,119.13 189.3,119.13 189.2,119.03 189.1,119.03
  BOTTOM w0.127: v2(222.38,121.05) 222.54,121.21 222.54,121.83 222.58,121.87 222.58,122.25 222.54,122.29 222.54,134.31 222.97,134.74 238.97,134.74 245.41,128.3 269.88,128.3 288.52,146.93 288.52,172.33 294.74,178.55 J12.47
SOC_EHRPWM5A: length 202.9
  TOP w0.127: U1.E17 v1(179.61,115.41)
  L08_SIG2 w0.102: 189.1,113.02 188.95,113.02 188.54,112.61 187.5,112.61 187.2,112.31 183.82,112.31 183.51,112.61 181.03,112.61 180.77,112.87 180.77,114.14 180.02,114.89 180.02,115 v1(179.61,115.41)
  L08_SIG2 w0.127: v2(208.58,108.77) 206.68,108.77 204.98,110.48 201.3,110.48 199.95,111.83 198.62,111.83 198.41,112.03 193.76,112.03 193.35,112.44 191.06,112.44 190.47,113.02 189.1,113.02
  BOTTOM w0.127: v2(208.58,108.77) 209.07,109.27 214.28,109.27 217.63,112.61 217.63,117.88 219.48,119.73 219.48,134.85 221.59,136.96 241.01,136.96 247.15,130.81 268.84,130.81 286.04,148.01 286.04,177.85 297.43,189.24 297.43,195.39 299.5,197.45 301.36,197.45 J12.34
