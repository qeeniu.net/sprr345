# Allegro board PROC046_REVA_BOARD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SOC_UART2_TXD: length 195.4
  TOP w0.127: U76.4 45.14,117.42 45.21,117.5 45.21,118.25 v2(45.47,118.51) ; U1.D21 v1(181.21,113.01) ; U124.8 44.41,105.47 44.22,105.65 43.12,105.65 43.09,105.68 v2(42.65,105.68)
  L03_SIG1 w0.102: 180.31,113.43 179.45,113.43 179.22,113.65 179.22,113.93 179.19,113.97 179.19,113.97 178.97,114.19 178.96,114.19 178.94,114.21 178.67,114.21 178.43,114.46 178.43,114.75 178.18,115 177.88,115 177.62,115.25 177.62,115.58 177.41,115.8 171.41,115.8 171.2,115.58 171.2,110.35 170.66,109.82 166.67,109.82 165.66,108.8 164.97,108.8 163.37,107.2 161.21,107.2
  L03_SIG1 w0.127: v2(42.65,105.68) 43.81,105.68 44.07,105.93 44.07,108.8 44.82,109.55 44.82,112.14 45.47,112.79 45.47,114.95 44.07,116.35 44.07,118.12 44.45,118.51 v2(45.47,118.51) 45.47,116.7 70.21,91.96 99.84,91.96 99.86,91.98 100.27,91.98 100.28,91.96 109.46,91.96 112.59,88.83 112.81,88.61 131.62,88.61 133.8,86.42 147.12,86.42 147.44,86.42 150.4,89.38 150.4,92.1 150.46,92.16 150.46,100.59 153.73,103.86 154.95,103.86 158.83,107.74 160.68,107.74 161.21,107.2 ; v1(181.21,113.01) 180.73,113.01 180.31,113.43
SOC_USB0_DM: length 114.2
  TOP w0.104: v2(215.72,31.46) 216.03,31.16 216.03,30.49 215.65,30.12 215.65,29.02 215.55,28.92 215.45,28.92 215.34,28.81 L12.1 ; U1.B18 182.81,115.41 187.88,115.41 190.5,112.79 193.76,112.79 195.25,111.29 198.43,111.29 200.15,109.57 200.15,105.63 200.31,105.48 200.47,105.48 v2(200.79,105.8)
  L08_SIG2 w0.127: v2(215.72,31.46) 215.94,31.46 216.07,31.34 216.07,30.89 215.94,30.76 212.97,30.76 206.17,37.56 206.17,56.86 201.06,61.97 201.06,76.7 200.55,77.21 200.55,101.94 201.98,103.37 201.98,104.96 201.81,105.13 201.81,105.13 201.15,105.8 v2(200.79,105.8)
SOC_USB0_DP: length 114.2
  TOP w0.104: U1.A18 183.37,115.18 187.78,115.18 190.4,112.55 193.66,112.55 195.16,111.06 198.33,111.06 199.92,109.47 199.92,105.53 200.21,105.24 200.38,105.24 v2(200.79,104.84) ; v2(216.69,31.46) 216.26,31.04 216.26,30.4 215.89,30.03 215.89,29.02 216,28.92 216.1,28.92 216.2,28.81 L12.4
  L08_SIG2 w0.127: v2(216.69,31.46) 216.46,31.46 216.34,31.34 216.34,30.77 216.05,30.49 212.85,30.49 205.9,37.44 205.9,56.75 200.79,61.86 200.79,76.59 200.28,77.1 200.28,102.06 201.71,103.48 201.71,104.84 201.62,104.93 201.61,104.93 201.22,105.32 200.91,105.32 200.79,105.2 v2(200.79,104.84)
SOC_USB0_ID: length 7.3
  TOP w0.127: U1.A19 185.33,114.21 v1(185.72,114.61)
  BOTTOM w0.127: v1(185.72,114.61) 185.93,114.81 187.72,114.81 188.25,114.28 R440.2
SOC_USB0_VBUSEN: length 100.7
  TOP w0.127: U54.4 v2(212.4,51.27) ; U1.E19 v1(179.61,113.81)
  L03_SIG1 w0.102: 189.1,114.16 184.35,114.16 182.68,115.84 182.17,115.84 182.17,115.83 180.56,115.83 180.24,115.51 180.24,114.44 v1(179.61,113.81)
  L03_SIG1 w0.127: v2(210.95,97.55) 211.33,97.93 211.33,99.96 210.69,100.6 208.41,100.6 207.04,99.23 202.13,99.23 201.41,99.95 201.41,101.45 201.42,101.46 201.42,107.33 201.17,107.58 200.69,107.58 200.56,107.71 200.56,111.06 199.86,111.76 198.83,111.76 198.35,112.24 195.64,112.24 195.63,112.24 191.02,112.24 189.1,114.16
  L08_SIG2 w0.127: v2(210.95,97.55) 211.34,97.16 211.34,89.18 210.68,88.52 210.68,52.99 v2(212.4,51.27)
  BOTTOM w0.127: R727.2 213.65,51.27 v2(212.4,51.27)
SOC_USB0_XO: length 49.4
  TOP w0.104: v2(155.27,89.6) 154.79,89.12 154.79,88.23 R489.2
  TOP w0.127: U1.D19 v1(181.21,114.61)
  L03_SIG1 w0.102: v1(181.21,114.61) 181.21,114.36 181.61,113.96 181.61,113.67 181.88,113.4 182.34,113.4 182.64,113.1 182.65,113.1 183,112.75 183,112.52 182.9,112.42 182.66,112.42 182.55,112.31 182.55,112.11 182.65,112.01 182.9,112.01 183,111.91 183,111.71 182.9,111.61 182.69,111.61 182.58,111.5 182.58,111.3 182.68,111.2 182.9,111.2 183,111.1 183,110.5 182.07,109.57 178.46,109.57 176.53,107.63 173,107.63 171.73,106.36 168.2,106.36 167.51,105.68 167.51,104.46 167.31,104.25
  L03_SIG1 w0.127: 167.31,104.25 166.43,104.25 162.17,99.99 159.31,99.99 157.51,98.19 157.51,92.17 155.63,90.29 155.63,89.96 v2(155.27,89.6)
SOC_USB1_DM: length 118.9
  TOP w0.104: v2(198.37,104.65) 198.7,104.98 198.7,108.88 197.84,109.74 194.67,109.74 193.07,111.34 189.03,111.34 186.79,113.58 186.17,113.58 186.07,113.47 186.07,113.25 185.96,113.15 185.81,113.15 185.71,113.25 185.71,113.47 185.6,113.58 185.45,113.58 185.35,113.47 185.35,113.25 185.24,113.15 185.09,113.15 184.99,113.25 184.99,113.47 184.89,113.58 183.37,113.58 U1.A20 ; v2(205.85,31.64) 205.98,31.76 206.14,31.76 206.25,31.66 206.25,22.11 202.67,18.53 199.16,18.53 198.83,18.86 L11.1
  L08_SIG2 w0.127: v2(205.85,31.64) 206.21,32 206.21,33.79 204.09,35.91 204.09,54.62 198.9,59.82 198.9,104.51 198.76,104.65 v2(198.37,104.65)
SOC_USB1_DP: length 118.8
  TOP w0.104: L11.4 198.83,18 199.13,18.3 202.76,18.3 206.48,22.02 206.48,31.53 206.59,31.64 v2(206.84,31.64) ; U1.B20 182.81,113.81 186.89,113.81 189.12,111.58 193.16,111.58 194.76,109.98 197.93,109.98 198.93,108.98 198.93,105.12 v2(199.39,104.66)
  L08_SIG2 w0.127: v2(199.39,104.66) 199.17,104.45 199.17,59.93 204.36,54.74 204.36,36.02 206.48,33.9 206.48,32 v2(206.84,31.64)
SOC_USB1_ID: length 21
  TOP w0.127: R446.1 v2(194.74,106.69) ; U1.E20 v1(179.61,113.01)
  L08_SIG2 w0.102: 189.1,109.22 189.1,109.24 188.42,109.92 188.11,109.92 187.53,109.34 186.47,109.34 185.42,110.38 183.08,110.38 182.99,110.29 181.22,110.29 180.37,111.14 180.37,112.26 v1(179.61,113.01)
  L08_SIG2 w0.127: 189.1,109.22 189.1,109.21 189.54,108.77 191.27,108.77 193.42,106.62 193.42,106.4 193.69,106.14 194.18,106.14 v2(194.74,106.69)
SOC_USB1_VBUSEN: length 132.1
  TOP w0.127: U57.4 v2(191.8,24.2) ; v1(184.48,113.01) 182.81,113.01 U1.B21
  L03_SIG1 w0.102: 189.1,108.65 188.88,108.88 185.27,108.88 185,109.15 185,112.5 v1(184.48,113.01)
  L03_SIG1 w0.127: v2(191.8,24.2) 192.74,23.26 196.47,23.26 197.99,24.78 200.66,24.78 202.97,27.09 202.97,32.58 205.89,35.5 209.98,35.5 v2(211.96,37.48) ; v2(203.56,97.68) 202.92,98.31 193.04,98.31 192.79,98.57 192.79,100.84 192.63,100.99 192.63,105.12 189.1,108.65
  L08_SIG2 w0.127: v2(203.56,97.68) 203.56,97.23 203.79,97 203.79,96.24 204.05,95.98 204.22,95.98 205.33,94.86 205.33,82.56 203.2,80.43 203.2,74.79 202.44,74.03 202.44,62.63 208.66,56.4 208.66,49.54 211.96,46.24 v2(211.96,37.48)
  BOTTOM w0.127: v2(191.8,24.2) R736.2
SOC_USB1_XO: length 49.4
  TOP w0.104: v2(156.13,86.92) 155.84,86.63 R488.2
  TOP w0.127: U1.C20 v1(182.01,113.81)
  L03_SIG1 w0.102: 167.56,104.03 167.76,104.23 167.76,105.58 168.3,106.11 171.83,106.11 173.1,107.38 176.63,107.38 178.56,109.31 182.17,109.31 183.25,110.39 183.25,112.85 182.82,113.28 182.82,113.28 182.68,113.43 182.68,113.55 182.42,113.81 v1(182.01,113.81)
  L03_SIG1 w0.127: v2(156.13,86.92) 156.13,90.4 157.78,92.05 157.78,98.07 159.42,99.71 162.28,99.71 166.55,103.98 167.51,103.98 167.56,104.03
SOC_VPP_EN: length 8.5
  TOP w0.127: 131.57,106.44 132.51,105.5 R833.1 133.39,105.08 131.8,103.49 131.8,101.08 132.05,100.83 132.89,100.83 U122.4
SPARE0: length 9.1
  TOP w0.127: U12.20 253.86,99.19 254.25,99.58 257.38,99.58 TP37.1
SPARE1: length 8.6
  TOP w0.127: TP38.1 258.7,99.07 254.25,99.07 253.57,98.39 U12.19
T_RTCK: length 45.3
  TOP w0.127: R80.2 R783.2 v2(255.79,105.92) ; v2(223.01,95.65) 223.01,95.93 222.3,96.64 U41.16
  L08_SIG2 w0.127: v2(241.36,98.31) 236.85,98.31 231.67,93.13 224.38,93.13 223.01,94.5 v2(223.01,95.65)
  BOTTOM w0.127: v2(255.79,105.92) 248.19,98.31 v2(241.36,98.31)
T_SRST_N: length 27.9
  TOP w0.127: R122.2 v2(243.59,108.69) ; v2(222.25,102.5) 222.3,102.46 U41.9
  BOTTOM w0.127: v2(243.59,108.69) 243.04,109.23 236.5,109.23 231.67,104.41 228.6,104.41 227.2,103.01 226.06,103.01 225.81,103.27 224.92,103.27 224.16,102.5 v2(222.25,102.5) 222.12,102.63 221.61,102.63 221.5,102.74 R905.2
T_TCK: length 16.9
  TOP w0.127: U41.8 222.8,102.76 222.63,102.92 v2(222.63,103.52) ; R144.2 v2(234.94,102.49) ; U41.3 v2(225.3,102.63)
  L03_SIG1 w0.127: v2(234.94,102.49) 234.49,102.49 234.35,102.63 v2(225.3,102.63) 224.28,103.65 222.76,103.65 v2(222.63,103.52)
T_TDI: length 20.8
  TOP w0.127: U41.4 224.8,102.89 226.57,104.66 229.49,104.66 230.5,103.65 230.5,98.19 230.12,97.8 230.12,96.41 230.76,95.77 233.44,95.77 233.82,96.15 R147.2
T_TDIS: length 7.4
  TOP w0.127: R77.2 258.8,98.06 258.91,97.95 R72.1 260.43,97.95 260.54,98.06 TP36.1 R889.2
T_TMS: length 16
  TOP w0.127: R146.2 v2(230.76,96.79) ; U41.6 223.8,103.12 v2(223.77,103.14)
  L03_SIG1 w0.127: v2(230.76,96.79) 229.87,95.9 227.46,95.9 226.63,96.73 226.63,100.03 224.09,102.57 224.09,102.82 v2(223.77,103.14)
  BOTTOM w0.127: R146.2 v2(230.76,96.79)
T_TRST_N: length 15
  TOP w0.127: R145.2 230.78,99.42 230.78,104 229.87,104.92 226.31,104.92 224.3,102.9 U41.5
TDI: length 5
  TOP w0.127: J5.A6 217.87,235.02 220.23,237.38 R38.2
TEMP_INT: length 144.1
  TOP w0.127: v1(184.22,117.62) 184.02,117.62 183.83,117.81 182.81,117.81 U1.B15 ; U112.3 158.28,143.86 v2(160.53,141.62)
  L03_SIG1 w0.102: 188.98,115.71 188.6,116.09 186.94,116.09 185.55,117.49 184.35,117.49 v1(184.22,117.62)
  L03_SIG1 w0.127: v2(201.68,149.75) 200.91,150.51 193.09,150.51 189.51,146.93 181.73,146.93 180.85,146.05 180.85,140.65 179.76,139.56 175.49,139.56 v2(174.93,140.12) ; v2(207.11,111.52) 206.22,110.63 202.18,110.63 199.4,113.41 195.64,113.41 194.49,114.57 190.12,114.57 188.98,115.71
  L08_SIG2 w0.127: v2(217.4,143.58) 215.16,145.81 213.61,145.81 210.06,149.37 208.99,149.37 207.52,150.84 202.77,150.84 v2(201.68,149.75)
  BOTTOM w0.127: v2(160.53,141.62) 161.16,140.98 164.08,140.98 164.85,141.75 170.61,141.75 171.78,140.58 174.47,140.58 v2(174.93,140.12) ; v2(207.11,111.52) 207.2,111.61 212.8,111.61 214.99,113.79 214.99,118.91 213.77,120.13 213.77,138.24 217.4,141.87 v2(217.4,143.58)
TMS: length 5.7
  TOP w0.127: J5.A8 217.64,233.02 217.96,233.34 217.96,234.48 218.95,235.47 R43.2
TOUCH_INTN: length 183.4
  TOP w0.127: J21.5 v2(70.03,56.8) ; U1.D16 v1(181.21,117.01)
  L03_SIG1 w0.102: 161.21,108.41 161.21,108.37 161.87,107.71 163.04,107.71 164.63,109.3 165.57,109.3 166.5,110.23 169.44,110.23 169.62,110.4 169.62,116.42 169.8,116.6 170.18,116.6 170.42,116.84 170.42,117.15 170.43,117.15 170.43,117.17 170.65,117.39 170.67,117.39 170.68,117.4 178.16,117.4 178.39,117.17 178.39,116.82 178.57,116.65 178.59,116.65 178.6,116.63 179.38,116.63 180.14,117.39 180.66,117.39 180.92,117.13 181.09,117.13 v1(181.21,117.01)
  L03_SIG1 w0.127: v2(70.1,97.93) 73.46,94.58 98.4,94.58 98.82,94.16 108.59,94.16 112.43,90.31 131.19,90.31 133.11,88.39 147.63,88.39 149.63,90.4 149.63,92.41 149.69,92.47 149.69,100.91 154.37,105.58 154.37,105.89 155.07,106.59 156.34,106.59 158.36,108.61 161.01,108.61 161.21,108.41
  BOTTOM w0.127: v2(70.1,97.93) 70.1,56.88 v2(70.03,56.8) R729.2
TPS65000_PG#: length 14
  TOP w0.127: U4.2 285.93,101.59 285.32,102.2 285.32,102.99 284.19,104.12 282.03,104.12 TP29.1 281.53,101.84 280.9,101.21 R67.1 U6.3
TPS_INT1: length 189
  TOP w0.127: U1.F23 v1(178.81,110.61) ; v2(256.26,156.61) 255.52,157.34 R341.2
  L03_SIG1 w0.127: v2(278.76,134.13) 274.87,130.23 254.55,130.23 252.81,131.97 v2(231.14,131.97) ; v2(186.28,98.82) 186.28,98.03 188.29,96.03 190.37,96.03 192.15,94.25 193.8,94.25 195.21,92.84 207.89,92.84 209.16,94.11 212.15,94.11 222.1,104.05 229.29,104.05 230.56,105.32 230.56,108.47 233.07,110.99 233.07,112.97 v2(232.69,113.35)
  L08_SIG2 w0.127: v2(256.26,156.61) 270,156.61 273.94,152.67 274.52,152.67 277.11,150.08 277.11,148.48 278.76,146.83 v2(278.76,134.13)
  BOTTOM w0.127: v1(178.81,110.61) 178.81,110.19 178.82,110.19 178.82,108.98 179.15,108.65 179.15,107.94 179.22,107.87 179.22,104.82 179.39,104.65 180.66,104.65 180.67,104.64 180.82,104.64 186.28,99.18 v2(186.28,98.82) ; v2(232.69,113.35) 231.65,114.39 231.65,131.46 v2(231.14,131.97)
TPS_SLEEP: length 149.9
  TOP w0.127: v1(184.41,108.14) 183.81,108.14 182.97,107.3 182.78,107.3 182.41,107.67 U1.B25 ; U32.F1 242.93,173.77 242.84,173.67 235.37,173.67 235.35,173.69 229.17,173.69 v2(228.85,174)
  L03_SIG1 w0.102: 185.17,104.03 185.17,107.39 v1(184.41,108.14)
  L03_SIG1 w0.127: 185.17,104.03 185.87,103.33 188.64,103.33 188.86,103.55 189.86,103.55 190.94,102.47 190.94,97.49 192.53,95.9 195.17,95.9 195.48,95.9 196.8,94.58 205.38,94.58 205.63,94.83 207.45,94.83 208.65,96.04 211.71,96.04 218.25,102.58 218.25,104.4 219.36,105.5 v2(220.34,105.5)
  L08_SIG2 w0.127: v2(228.85,174) 224.46,169.61 224.46,138.39 226.19,136.67 v2(226.19,132.09)
  BOTTOM w0.127: v2(220.34,105.5) 220.27,105.58 218.21,105.58 217.47,106.31 217.47,108.37 221.54,112.44 223.82,112.44 226.82,115.43 226.82,130.95 226.19,131.59 v2(226.19,132.09)
TRANS_EMMC_RSTN: length 6
  TOP w0.127: R267.1 175.25,200.74 175.63,201.12 177.54,201.12 177.92,200.74 177.92,200.01 178.15,199.79 U34.4
TRGRSTZ: length 350.6
  TOP w0.102: v1(73.65,202.07) 73.65,201.68 73.69,201.64 73.69,200.95 73.91,200.73 U20.A8
  TOP w0.127: R348.2 221.61,96.76 221.8,96.94 U41.15 ; R348.2 222.16,96.04 222.35,95.85 U132.15 ; R348.2 221.04,96.04 220.8,96.29 220.8,96.86 219.65,98.01 217.73,98.01 213.83,94.11 213.83,88.5 213.51,88.18 212.93,88.18 212.52,87.77 211.28,87.77 208.38,84.88 190.84,84.88 181.29,75.33 133.78,75.33 132.38,76.72 128.8,76.72 127.18,75.1 v2(127.18,67.58) ; U23.1 v2(101.14,185.65)
  L08_SIG2 w0.127: v2(127.18,67.58) 126.8,67.96 96.14,67.96 94.23,66.05 94.23,64.91 96.65,62.5 v2(96.65,58.43) ; v2(101.14,185.65) 97.66,185.65 97.45,185.43 v2(94.87,185.43)
  BOTTOM w0.102: 77.98,201.31 77.37,200.7 75.23,200.7 74.78,201.16 74.78,201.41 74.47,201.72 74,201.72 v1(73.65,202.07)
  BOTTOM w0.127: 77.98,201.31 77.98,202.07 79.18,203.28 83.72,203.28 84.77,204.33 93.44,204.33 95.12,202.65 95.12,186.13 94.87,185.88 v2(94.87,185.43) ; v2(96.65,58.43) 103,64.78 103,90.59 105.6,93.19 105.6,96.01 102.36,99.25 102.36,125.74 100.58,127.52 100.58,185.09 v2(101.14,185.65)
TSC_WAKEN: length 142.2
  TOP w0.127: U58.1 v2(78.24,48.01) ; U35.17 90.92,174.06 91.27,174.41 91.27,174.41 91.8,174.93 v2(92.58,174.93) R277.1
  L03_SIG1 w0.127: v2(78.87,65.29) 77.11,63.54 77.11,60.18 77.18,60.11 77.18,59.7 77.11,59.64 77.11,49.14 v2(78.24,48.01) ; v2(86.61,161.3) 76.35,151.04 76.35,110.73 v2(78.36,108.73)
  BOTTOM w0.127: v2(92.58,174.93) 91.79,174.93 89.1,172.24 89.1,171.4 86.61,168.91 v2(86.61,161.3) ; v2(78.36,108.73) 78.36,65.8 v2(78.87,65.29)
TSC_WAKEN_AND: length 14.4
  TOP w0.127: J21.6 71.03,56.44 71.88,57.29 76.84,57.29 80.14,53.98 U58.4
UART0_TXVR_EN: length 238.6
  TOP w0.127: v2(16,47.64) 15.11,46.75 R435.2 ; U147.2 35.05,93.1 v2(35.31,93.36) ; U1.D22 v1(181.21,112.21)
  L03_SIG1 w0.102: 161.95,104.03 162.79,104.87 162.79,106.31 165.02,108.55 165.76,108.55 166.83,109.62 171.17,109.62 172.01,110.45 172.01,114.8 172.23,115.03 177.32,115.03 177.35,114.99 177.37,114.99 177.59,114.77 177.59,114.75 177.6,114.75 177.6,113.63 177.83,113.4 178.97,113.4 179.22,113.15 179.22,112.88 179.23,112.87 179.23,112.86 179.45,112.63 179.77,112.63 179.77,112.64 180.78,112.64 v1(181.21,112.21)
  L03_SIG1 w0.127: v2(35.31,93.36) 34.92,92.98 29.98,92.98 23.5,86.5 23.5,51.83 19.3,47.64 v2(16,47.64) ; 161.95,104.03 161.24,103.32 153.7,103.32 150.7,100.32 150.7,92.06 150.67,92.03 150.67,89.04 147.88,86.25 147.6,86.25 147.54,86.18 133.7,86.18 133.64,86.25 133.23,86.25 131.1,88.37 113.23,88.37 110.63,88.37 109.4,89.6 90.51,89.6 89.97,89.06 v2(63.84,89.06)
  BOTTOM w0.127: v2(35.31,93.36) 36.83,93.36 41.13,89.06 v2(63.84,89.06)
UEMU0: length 4.7
  TOP w0.127: U12.33 241.62,104.6 241.3,104.92 240.79,104.92 240.41,105.3 R129.1
UEMU1: length 4.1
  TOP w0.127: R125.1 242.06,105.3 242.42,104.94 U12.32
UEXP0: length 7.8
  TOP w0.127: U12.29 244.82,108.62 244.3,109.14 244.2,109.14 243.71,109.63 R121.1
UEXP1: length 7.5
  TOP w0.127: U12.28 245.62,108.22 245.87,108.47 R114.1
UEXP2: length 8.6
  TOP w0.127: R110.1 247.48,109.85 247.47,109.87 247.14,109.87 246.42,109.15 U12.27
UEXP3: length 7.6
  TOP w0.127: R104.1 250.06,106.95 249.62,106.5 U12.23
URTCK: length 5.4
  TOP w0.127: R80.1 253.87,103.27 253.62,103.01 253.62,100.98 253.43,100.79 U12.22
USB0_CONN_DM: length 6.8
  TOP w0.104: J35.2 214.81,22.37 214.95,22.51 215.38,22.51 215.69,22.82 215.69,23.74 D15.1 215.42,24.34 215.29,24.48 215.29,25.69 215.65,26.05 215.65,26.3 L12.2
USB0_CONN_DP: length 6.8
  TOP w0.104: J35.3 216.81,22.39 216.66,22.54 216.2,22.54 215.93,22.82 215.93,23.81 D15.2 216.12,24.39 216.26,24.53 216.26,25.69 215.88,26.07 215.88,26.29 L12.3
USB0_VDDA12: length 1.6
  TOP w0.127: U17.N17 v1(247.02,48.45)
  BOTTOM w0.381: v1(247.02,48.45) 247.04,48.47 C417.1
USB0_VDDA18: length 18.5
  TOP w0.127: 248.62,46.83 244.81,46.83 244.62,47.01 244.62,48.45 U17.N14
  TOP w0.381: C73.1 252.31,44.52 251.56,44.52 v2(251.43,44.39) ; v2(251.43,44.39) 251.03,44.79 250.65,44.79 248.62,46.83 ; v2(251.43,44.39) 251.43,42.74 251.69,42.48 FL5.3 252.41,42.15 252.37,42.12 252.37,41.44 252.44,41.38 C78.1
  BOTTOM w0.381: C415.2 C73.1 v2(251.43,44.39)
USB0_VDDA33: length 12.6
  TOP w0.127: 250.01,47.69 249.5,48.2 249.02,48.2 248.77,48.45 247.81,48.45 U17.N18
  TOP w0.381: v2(251.31,47.69) 251.31,46.73 251.69,46.34 FL3.3 ; v2(251.31,47.69) 250.9,47.29 250.42,47.29 250.01,47.69 ; v2(251.31,47.69) 251.69,48.07 C66.1
  BOTTOM w0.381: C412.1 C66.1 ; C66.1 C64.1 ; C66.1 251.69,48.07 v2(251.31,47.69)
USB1_CONN_DM: length 10.2
  TOP w0.104: L11.2 196.9,18.86 196.58,18.54 194.85,18.54 194.06,17.76 194.06,15.39 193.7,15.03 193.7,13.8 193.83,13.67 D14.1 194.03,13.14 194.03,12.39 193.83,12.19 J38.2
USB1_CONN_DP: length 9.8
  TOP w0.104: J38.3 194.48,12.19 194.27,12.39 194.27,13.08 D14.2 194.53,13.7 194.67,13.83 194.67,15.03 194.3,15.39 194.3,17.66 194.94,18.3 196.6,18.3 196.9,18 L11.3
USB1_CONN_ID: length 135.3
  TOP w0.127: J38.4 195.13,12.49 197.9,15.26 U109.3 198.62,14.92 198.36,14.66 R584.2 198.36,13.11 198.55,12.92 201.75,12.92 203.02,14.19 203.02,17.11 207.64,21.73 v2(207.64,30.49) ; R446.2 v2(197.96,106.69)
  L08_SIG2 w0.127: v2(197.96,106.69) 199.14,106.69 199.45,107.01 201.79,107.01 203.05,105.76 203.05,103.06 201.55,101.56 201.55,98.4 203.38,96.58 203.38,96.18 204.44,95.11 204.44,82.9 202.16,80.61 202.16,62.47 208.05,56.58 208.05,48.88 211.43,45.51 211.43,36.82 213.46,34.79 215.72,34.79 217.87,32.64 217.87,30.36 217.04,29.53 208.61,29.53 v2(207.64,30.49)
USRSTN: length 4.1
  TOP w0.127: R122.1 243.59,105.17 243.22,104.8 U12.31
UTCK: length 4
  TOP w0.127: U12.34 237.81,100.79 237.11,101.49 R144.1
UTDI: length 4.9
  TOP w0.127: R147.1 236.23,97.18 236.64,97.59 U12.38
UTDIS: length 5
  TOP w0.127: U12.18 v2(253.75,97.59) 254.22,98.06 R77.1
  BOTTOM w0.127: R77.1 253.87,98.06 253.75,97.93 v2(253.75,97.59)
UTDO: length 25.7
  TOP w0.127: U12.21 251.22,100.09 v2(248.06,100.09) ; R81.1 v2(228.47,97.17)
  L03_SIG1 w0.127: v2(248.06,100.09) 241.45,100.09 240.39,99.02 229.59,99.02 228.85,98.29 228.85,97.55 v2(228.47,97.17)
UTMS: length 7.5
  TOP w0.127: U12.37 235.41,98.39 233.81,96.79 R146.1
UTMSK: length 15.8
  TOP w0.127: U12.30 244.02,101.56 244.73,100.85 244.73,100.86 v2(244.74,100.86)
  BOTTOM w0.127: R643.1 233.06,97.59 236.32,100.85 244.73,100.85 v2(244.74,100.86)
UTRSTN: length 7.2
  TOP w0.127: R145.1 234.57,98.44 235.32,99.19 U12.36
VBACKUP: length 24.2
  TOP w0.102: U32.D7 v1(246.79,174.74)
  L03_SIG1 w0.127: v1(246.79,174.74) 248.87,174.74 249.5,174.11 256.49,174.11 259.51,177.13 267.16,177.13 268.48,178.45
VCAN0: length 6.1
  TOP w0.381: v2(38.99,178.63) U118.7 ; U100.8 C347.1
  BOTTOM w0.381: v2(38.99,178.63) 37.71,179.91 C753.1
VCAN1: length 5.9
  TOP w0.381: U119.7 38.99,143.25 v2(38.1,142.36)
  BOTTOM w0.381: C755.1 37.21,141.47 v2(38.1,142.36)
VCNTL0: length 36.2
  TOP w0.127: U1.Y1 168.01,130.07 167.59,130.49 v1(167.21,130.49) ; v2(157.66,153.1) 158.12,153.1 159.77,154.75 160.73,154.75 161.16,154.32 R814.1
  L03_SIG1 w0.102: 164.47,134.89 164.47,131.54 165.56,130.44 167.16,130.44 v1(167.21,130.49)
  L03_SIG1 w0.127: v2(157.66,153.1) 158.37,153.1 159.13,152.34 159.13,147.59 159.68,147.04 159.68,141.33 160.66,140.34 161.6,140.34 162.46,139.49 162.46,136.9 164.47,134.89
VCNTL1: length 35.8
  TOP w0.127: R815.1 162.04,152.82 160.81,154.04 160.81,154.07 160.49,154.38 160.08,154.38 158.24,152.54 156.97,152.54 156.08,151.65 156.08,144.54 157.23,143.4 157.59,143.4 159.77,141.22 159.77,139.69 165.58,133.88 165.58,133.87 165.58,132.13 165.99,131.71 166.24,131.71 166.56,131.4 166.56,130.33 167.21,129.68 U1.AA1
VCNTL2: length 19.2
  TOP w0.102: 164.08,131.71 166.41,129.39
  TOP w0.127: 164.08,131.71 164.08,134.51 158.5,140.1 154.81,140.1 TP140.1 ; 166.41,129.39 U1.AB1
VCNTL3: length 21.3
  TOP w0.127: U1.AA2 166.8,128.22 166.8,129.5 164.46,131.84 164.46,134.56 156.51,142.51 TP133.1
VCNTL4: length 19
  TOP w0.102: 166.01,129.41 163.7,131.71
  TOP w0.127: 163.7,131.71 163.7,134.53 159.54,138.7 TP139.1 ; U1.AB2 166.01,128.21 166.01,129.41
VCNTL5: length 16.8
  TOP w0.102: 163.35,131.68 165.61,129.43
  TOP w0.127: TP136.1 154.51,136.59 161.3,136.59 163.35,134.54 163.35,131.68 ; 165.61,129.43 U1.AC1
VCOM_BAT: length 11.1
  TOP w0.381: U8.4 v2(191.67,230.43) ; v2(191.67,230.43) 191.67,229.48 192.41,228.74 C27.1 ; v2(191.67,230.43) 191.35,230.43 191.13,230.65 191.13,230.95 v2(191.27,231.08) ; C21.1 190.32,231.08 v2(191.27,231.08) ; v2(191.27,231.08) U8.3 ; FB2.1 v2(198.15,246.49)
  BOTTOM w0.381: C27.1 193.28,230.07 192.91,230.43 v2(191.67,230.43)
  vias: v2(190.63,229.88) v2(191.13,229.25) v2(191.64,228.74) v2(192.28,228.11) v2(198.63,245.38) v2(199.52,245.38) v2(200.02,246.39)
VCOM_BAT_FB: length 21.2
  TOP w0.381: 199.52,247.16 199.9,247.54 199.9,248.05 v2(199.77,248.17) ; 199.52,247.16 200.41,247.16 200.66,247.41 200.66,247.92 v2(200.53,248.05) ; 199.52,247.16 FB2.2 v2(199.1,248.14) 196.56,248.14 195.31,246.89 193.82,246.89 193.55,247.16 J2.5 ; J2.7 192.91,249.95
  BOTTOM w0.381: v2(193.42,249.95) 193.42,248.93 192.91,248.43 C362.1 191.27,247.29 C361.1 191.13,248.6 v2(192.43,249.9)
  vias: v2(198.37,248.93) v2(199.14,248.93) v2(200.53,248.81)
VCOM_BATEN: length 3.2
  TOP w0.381: R69.2 197.56,232.38 v2(196.44,232.38) U8.8
  BOTTOM w0.381: v2(196.44,232.38) 197.56,232.38 R69.2
VCOM_BATFB: length 8.5
  TOP w0.381: v2(196.44,230.43) 196.44,228.97 196.22,228.74 C27.2 ; v2(196.44,230.43) 197.68,230.43 R73.1 ; v2(196.44,230.43) U8.5
  BOTTOM w0.381: C27.2 195.35,228.74 196.44,229.83 v2(196.44,230.43)
VCTCXO_20M: length 14.4
  TOP w0.127: U60.5 C274.1 133.68,90.36 135.37,88.67 U62.8
VER0: length 10.2
  TOP w0.127: U17.C4 235.81,57.25 235.81,58.66 235.52,58.96
  TOP w0.381: R97.1 v2(232.64,63.82) 233.76,62.7 233.76,60.72 235.52,58.96
  BOTTOM w0.381: R97.1 v2(232.64,63.82)
VER1: length 9.7
  TOP w0.127: 234.54,59.12 235.05,58.61 235.05,58.02 U17.B3
  TOP w0.381: 234.54,59.12 233.09,60.57 233.09,61.84 v2(231.11,63.82) R96.1
  BOTTOM w0.381: R96.1 v2(231.11,63.82)
VER2: length 8.6
  TOP w0.127: 236.6,59.12 236.6,58.03 U17.B4
  TOP w0.381: R98.1 v2(235.69,63.69) 235.69,60.36 236.6,59.44 236.6,59.12
  BOTTOM w0.381: R98.1 v2(235.69,63.69)
VER3: length 8
  TOP w0.127: U17.A4 236.22,59.01 236.09,59.14
  TOP w0.381: 236.09,59.14 235.01,60.22 235.01,62.97 v2(234.16,63.82) R99.1
  BOTTOM w0.381: R99.1 v2(234.16,63.82)
VETH1_AVDDH: length 42.7
  TOP w0.254: U92.47 168.06,49.38 v2(167.56,48.88) ; U92.1 169.97,47.4 169.54,46.98 C341.1 ; 175.47,47.89 U92.12
  TOP w0.381: v2(177.24,46.15) C346.1 176.02,47.34 175.47,47.89 ; Q13.3 v2(154.6,50.7) ; FB11.2 151.94,49.53 v2(151.94,50.81) ; C341.1 v2(168.77,46.18)
  L03_SIG1 w0.635: v2(177.24,46.15) 168.8,46.15 v2(168.77,46.18) 167.56,47.4 v2(167.56,48.88) 166.01,48.88 165.49,48.35 163.25,48.35 159.89,51.7 155.6,51.7 v2(154.6,50.7)
  BOTTOM w0.381: v2(154.6,50.7) 154.6,48.94 155,48.53 C342.1
  vias: v2(150.95,51.04) v2(150.93,50.05)
VETH1_AVDDL: length 12
  TOP w0.203: U92.9 v2(173.97,47.44)
  TOP w0.254: U92.4 v2(171.47,47.18)
  L03_SIG1 w0.381: v2(171.47,47.18) 173.73,47.18 173.97,47.42 v2(173.97,47.44)
  BOTTOM w0.508: C337.1 173.97,46.21 v2(173.97,47.44) ; FB40.2 170.65,43.28 170.38,43.55 170.38,45.71 170.71,46.04 170.74,46.04 170.8,46.11 C333.1 171.47,46.11 v2(171.47,47.18)
VETH1_AVDDL_PLL: length 9.4
  TOP w0.254: U92.44 v2(168.57,50.88)
  BOTTOM w0.508: v2(168.57,50.88) 167.68,50.88 167.4,50.6 C340.1 ; v2(168.57,50.88) 168.57,47.87 168.2,47.49 FB36.2 ; v2(168.57,50.88) 169.39,50.88 C685.1 169.61,51.09 C686.1
VETH1_AVDDL_PMOS: length 13.1
  TOP w0.381: Q13.4 157.1,42.69 v2(159.31,42.69) ; C327.1 v2(164,39.77) ; Q13.2 v2(156.9,50.7)
  BOTTOM w0.381: FB36.1 164.59,47.49 v2(164.41,47.31)
  BOTTOM w0.508: v2(177.14,42.74) 177.09,42.79 177.09,43.45 176.39,44.15 FB37.1 ; FB40.1 172.65,41.48 172.87,41.26 175.46,41.26 175.5,41.3 175.69,41.3 v2(176.14,41.75)
  vias: v2(156.08,39.77) v2(157.07,39.77) v2(157.68,50.71) v2(158.5,50.74) v2(159.41,50.74)
VETH1_DVDDH: length 179.1
  TOP w0.203: U92.16 v2(176.9,50.38)
  TOP w0.254: v2(168.22,53.06) 168.41,52.88 U92.40 ; U92.34 v2(170.97,56.02)
  TOP w0.381: v2(164.75,54.24) R566.1 163.5,53.48 162.72,54.27 D4.1 161.59,55.39 160.45,54.24 159.67,54.24 R570.1 ; R565.1 164.63,57.58 v2(164.21,57.16) ; R541.2 173.15,64.29 173.15,64.95 v2(173.28,65.08) ; R530.2 179.76,48.26 ; 179.76,48.26 v2(179.76,48.96) ; 179.76,48.26 179.99,48.02 181.74,48.02 181.89,47.86 U89.5 183.12,46.43 v2(183.18,46.37) ; R559.2 v2(168.71,65.08) ; v2(182.5,51.07) 182.52,51.09 R527.2 ; R533.2 v2(174.8,65.08) ; U88.5 v2(182.18,38.86) ; R531.2 v2(176.33,65.08) ; R552.2 v2(170.23,65.08)
  L03_SIG1 w0.381: v2(182.18,38.86) 182.18,25.35 v2(183.13,24.4) ; v2(164.21,57.16) 164.75,56.62 v2(164.75,54.24) ; v2(164.75,54.24) 167.13,54.24 168.1,53.28 168.43,53.28 169.11,53.96 169.11,54.17 v2(170.97,56.02) 169.49,57.5 169.49,62.73 168.71,63.51 v2(168.71,65.08) v2(170.23,65.08) 170.88,64.43 172.63,64.43 v2(173.28,65.08) v2(174.8,65.08) v2(176.33,65.08) ; v2(164.75,54.24) 164.75,51.57 165.51,50.81 167.77,50.81 169.44,49.14 175.66,49.14 v2(176.9,50.38)
  L08_SIG2 w0.305: v2(176.9,50.38) 176.3,49.78 176.3,48.94 176.45,48.78 179.58,48.78 v2(179.76,48.96)
  L08_SIG2 w0.381: v2(183.13,24.4) 182.88,24.65 179.45,24.65 177.67,22.87 156.08,22.87 154.18,20.97 v2(154.18,17.67)
  BOTTOM w0.381: v2(183.13,24.4) 183.12,24.38 R585.1 ; v2(183.18,46.37) 182.95,46.13 C672.2 ; C310.1 171.62,55.38 v2(170.97,56.02) ; R759.2 172.28,64.16 172.52,64.4 172.52,64.78 172.77,65.04 173.24,65.04 v2(173.28,65.08) ; v2(168.22,53.06) 168.22,53.08 168.5,53.35 ; C312.1 175.95,51.33 v2(176.9,50.38) ; R586.1 154.16,17.65 v2(154.18,17.67) ; R751.2 v2(179.76,48.96)
  BOTTOM w0.762: v2(164.21,57.16) 164.63,57.58 R565.1 ; R751.2 181.34,49.91 ; v2(164.75,54.24) 165.17,54.65 R767.1
  BOTTOM w1.016: v2(182.5,51.07) 183.16,51.07 185.45,48.78 185.45,44.72 182.18,41.46 C673.1 v2(182.18,38.86) ; v2(182.5,51.07) 181.34,49.91 ; v2(182.5,51.07) 182.88,51.45 182.88,53.69 179.32,57.24 170.64,57.24 169.77,56.38 169.77,54.47 169.32,54.02 169.16,54.02 168.5,53.35
VETH1_DVDDL: length 37.5
  TOP w0.254: U92.39 169.4,53.35 168.81,53.35 168.37,53.79 167.57,53.79 167.18,53.41 v2(167.18,53.23) ; v2(177.91,54.38) 177.63,54.09 177.02,54.09 176.84,53.91 176.05,53.91 U92.23 ; U92.26 v2(174.97,56.02) ; U92.14 v2(176.9,49.38) ; U92.30 v2(172.97,56.02) ; U92.18 v2(176.9,51.38)
  TOP w0.381: v2(177.91,54.38) 179.01,54.38 C330.1
  L03_SIG1 w0.203: 177.11,51.17 177.39,50.88 177.39,49.88 v2(176.9,49.38)
  L03_SIG1 w0.508: v2(174.97,56.02) v2(172.97,56.02) 172.33,56.02 168.73,52.42 167.46,52.42 167.18,52.69 v2(167.18,53.23) ; v2(174.97,56.02) 175.72,56.02 176.23,55.51 177.44,55.51 177.91,55.05 v2(177.91,54.38) ; v2(174.97,56.02) 174.97,54.97 175.92,54.02 175.92,52.03 176.63,51.32 176.84,51.32 v2(176.9,51.38) 177.11,51.17
  BOTTOM w0.381: FB37.2 176.02,47.31 176.53,47.82 175.79,48.55 C329.1 175.3,48.82 175.87,49.39 176.31,49.39 176.32,49.38 v2(176.9,49.38)
VHDMI_AVCC12: length 21.5
  TOP w0.254: v2(97.1,35.55) 97.1,36.44 96.96,36.59 U102.66 ; v2(97.54,38.88) 97.54,38.93 96.88,39.59 U102.60
  TOP w0.381: C319.1 v2(91.26,43.46)
  L08_SIG2 w0.381: v2(91.26,43.46) 91.67,43.06 95.26,43.06 97.54,40.78 v2(97.54,38.88) 96.7,38.04 96.7,35.95 v2(97.1,35.55)
  BOTTOM w0.381: C684.1 96.2,35.88 96.53,35.55 v2(97.1,35.55) ; v2(97.54,38.88) 96.39,38.88 96.2,39.07 C683.1
VHDMI_CVCC12: length 54.8
  TOP w0.203: v2(99.92,44.95) 100.42,44.45 U102.47 ; U102.5 98.92,31.22 v2(99.42,30.72) ; v2(97.1,44.06) 97.42,43.74 U102.53
  TOP w0.254: U102.42 v2(102.92,44.06) ; U102.26 v2(107.39,37.09) ; U102.12 v2(102.42,31.61)
  TOP w0.381: FB39.1 95.78,45.38 v2(97.1,44.06)
  L08_SIG2 w0.381: v2(99.92,44.95) 99.03,44.06 v2(97.1,44.06)
  BOTTOM w0.203: 102.41,44.56 102.41,45.35 102.36,45.4 ; 99.78,31.11 99.92,31.26 99.92,32.53 100.28,32.88 101.69,32.88 101.7,32.87 C694.1
  BOTTOM w0.254: v2(99.42,30.72) 99.78,31.08 99.78,31.11 ; v2(99.92,44.95) 100.55,45.58 102.18,45.58 102.36,45.4 ; v2(102.92,44.06) 102.41,44.56 ; C698.1 107.77,42.8 108.08,42.5 108.08,41.29 107.67,40.88 106.88,40.88 105.76,39.76 105.76,37.87
  BOTTOM w0.381: v2(102.92,44.06) 102.92,42.96 C698.1 ; C689.1 99.57,43.53 99.01,44.08 98.55,44.08 98.53,44.06 v2(97.1,44.06) ; v2(107.39,37.09) 105.87,37.09 C700.1 105.76,37.87 105.48,38.15 104.66,38.15 104.09,38.72 102.57,38.72 102.17,38.33 102.17,35.56 102.44,35.3 103.07,35.3 103.33,35.04 103.33,33.14 103.06,32.87 C694.1 102.42,32.76 v2(102.42,31.61)
VHDMI_IOVCC: length 55.9
  TOP w0.203: v2(108.28,35.09) 107.78,34.59 U102.21
  TOP w0.254: U102.3 97.92,32.02 97.87,31.97 97.87,31.28 v2(98.42,30.72) ; U102.46 v2(100.92,44.06)
  TOP w0.381: R556.1 v2(97.74,48.25) ; v2(108.28,35.09) 108.3,35.07 109.06,35.07 109.69,34.43 C325.1 109.69,32.35 109.69,32.35 FB38.1 ; R562.1 v2(99.64,48.25)
  L03_SIG1 w0.381: v2(100.92,44.06) 100.92,45.1 99.64,46.37 v2(99.64,48.25)
  BOTTOM w0.203: 106.91,35.57 107.18,35.57 107.19,35.58 107.78,35.58 v2(108.28,35.09) 107.78,34.58 107.11,34.58 106.76,34.23 106.55,34.43 106.55,35.22 106.91,35.57
  BOTTOM w0.381: v2(100.92,44.06) 101.32,43.65 101.32,42.83 C693.1 100.79,42.8 100.53,42.55 100.53,34.79 99.14,33.39 R766.1 97.5,31.99 C701.1 97.81,31.18 97.96,31.18 v2(98.42,30.72) 99.56,29.58 105.61,29.58 106.76,30.72 106.76,34.23 ; v2(97.74,48.25) v2(99.64,48.25) 100.05,47.85 101,47.85 R769.1
VLED+: length 26.8
  TOP w0.203: J22.2 v2(35.14,62.54)
  TOP w0.254: U53.9 44.26,72.86 C235.1 v2(46.04,72.47) 46.55,72.47 46.86,72.15 TP152.1
  L03_SIG1 w0.381: v2(46.04,72.47) 46.04,68.66 38.91,61.53 36.14,61.53 v2(35.14,62.54)
  BOTTOM w0.381: v2(35.14,62.54) 33.92,62.54 33.46,62.08 C734.1
VLED-: length 28
  TOP w0.203: v2(35.14,63.55) 34.59,63.01 34.59,62.32 34.64,62.28 J22.1 ; R438.1 40.68,78.17 40.88,78.37 v2(42.76,78.37) U53.5
  L03_SIG1 w0.381: v2(42.76,78.37) 41.61,77.22 41.61,74.28 43.56,72.33 43.56,68.21 40.41,65.06 36.65,65.06 v2(35.14,63.55)
VOL+: length 106.7
  TOP w0.127: SW2.1 SW2.2 125.76,239.3 125.98,239.08 D6.1 127.07,237.89 127.22,238.03 R168.1 v2(127.76,238.97) ; U20.E3 v1(71.43,199.13)
  BOTTOM w0.127: v1(71.43,199.13) 71.02,199.13 70.87,199.28 70.87,200.93 69.85,201.94 69.85,207.43 72.26,209.85 72.26,216.51 74.16,218.4 78.89,223.14 78.89,237.58 80.58,239.27 113.42,239.27 114.43,238.27 127.06,238.27 v2(127.76,238.97)
VOL-: length 95.8
  TOP w0.127: v1(69.42,198.97) 69.66,198.73 U20.E2 ; SW4.1 SW4.2 117.12,239.25 v2(116.77,238.9) D8.1 117.32,238.01 117.34,238.03 R196.1
  BOTTOM w0.127: v2(116.77,238.9) 114.17,238.9 113.56,239.51 80.48,239.51 74.75,233.78 74.75,225.2 71.98,222.43 71.98,210.05 69.6,207.66 69.6,202.02 68.91,201.34 68.91,199.48 v1(69.42,198.97)
VPP1V8: length 54.1
  TOP w0.203: C759.2 129.43,106.94 131.07,106.94
  TOP w0.381: U1.W21 v1(168.41,112.21) U1.Y21 ; v2(128.51,106.63) 128.84,106.96 C759.2
  L03_SIG1 w0.102: 165.02,111.83 168.02,111.83 v1(168.41,112.21)
  L03_SIG1 w0.178: 165.02,111.83 164.47,111.27 164.47,110.86 162.97,109.36 161.34,109.36 161.09,109.62 160.82,109.62
  L03_SIG1 w0.254: 160.82,109.62 160.02,109.62 159.93,109.53 157.34,109.53 155.96,108.14
  L03_SIG1 w0.381: v2(128.51,106.63) 129.14,106.63 130.35,105.42 149.81,105.42 150.33,104.91 152.06,104.91 v2(152.25,105.09) 152.17,105.17 152.17,106.92 153.39,108.14 155.96,108.14
  BOTTOM w0.381: C760.1 155.36,107.42 154.61,106.67 154.61,106.01 153.7,105.09 v2(152.25,105.09)
VPP_EN: length 116.4
  TOP w0.127: v2(82.04,185.18) 81.05,186.17 81.05,189.28 80.62,189.71 79.25,189.71 77.93,191.03 U20.W16 ; U122.3 130.99,100.82 131.29,101.12 v2(131.29,102.88)
  L03_SIG1 w0.127: v2(131.29,102.88) 129.84,104.33 129.82,104.31 128.6,104.31 125.81,107.1 125.81,111.11 124.84,112.08 124.23,112.08 123.09,113.22 123.09,113.81 92.05,144.85 92.05,160.82 87.22,165.65 87.22,166.28 85.01,168.49 85.01,183.15 82.98,185.18 v2(82.04,185.18)
VRTC: length 129.9
  TOP w0.102: U32.B5 245.49,176.69
  TOP w0.127: 245.49,176.69 245.49,179.59 245.87,179.97
  TOP w0.178: v2(245.75,181.5) 245.87,181.37 245.87,179.97
  TOP w0.381: R294.1 278.64,169.31 v2(278.51,169.43)
  BOTTOM w0.381: v2(245.75,181.5) 245.49,181.5 243.97,183.02 C446.2 C439.1 TP84.1 ; TP84.1 242.33,187.23 243.89,188.79 248.69,188.79 257.15,180.33 277.7,180.33 279.12,178.91 279.12,170.04 v2(278.51,169.43) ; TP84.1 240.16,186.45 239.92,186.21 R668.1 239.14,186.96 238.63,187.47 230.63,187.47 225.68,182.51 225.68,163.9 227.58,161.99 234.52,161.99 234.87,161.64 ; 234.87,161.64 235.28,162.05 R888.2 ; 234.87,161.64 234.87,160.49 233.6,159.22 233.56,159.22 233.22,158.88 233.22,158.84 232.89,158.51 232.89,155.84 233.45,155.29 234.9,155.29 235.64,154.55 235.64,154.46 235.71,154.38 J13.1
VUSB_VBUS1: length 10.6
  TOP w0.254: U109.6 201.02,16.26 201.04,16.29 C354.2
  TOP w0.381: C354.2 v2(202.5,16.29)
  L08_SIG2 w0.508: 191.97,15.43 J30.1 ; J30.1 191.97,17.57 ; J30.1 193.04,16.5 ; J30.1 190.91,16.5
  BOTTOM w0.508: 191.97,15.43 J30.1 ; J30.1 191.97,17.57 ; J30.1 193.04,16.5
WARMRSTZ: length 58.4
  TOP w0.127: SW10.1 SW10.2 82.58,239.17 82.61,239.14 D11.1 ; v2(81.53,238.14) D11.1 ; D11.1 84.25,238.14 R313.1 ; U20.D7 v1(73.43,199.71)
  BOTTOM w0.127: v1(73.43,199.71) 72.84,199.71 70.41,202.15 70.41,207.2 72.82,209.62 72.82,216.28 74.72,218.17 79.38,222.83 79.38,237.38 80.14,238.14 v2(81.53,238.14)
WL_BT_EN: length 53.3
  TOP w0.127: v2(192.1,224.42) 195.35,224.42 196.2,223.58 R637.2 196.2,221.15 R139.1 196.23,220.58 196.3,220.5 U128.11
  L03_SIG1 w0.127: v2(192.1,224.42) 188.44,228.08 172.57,228.08 164.85,235.8 164.85,241.94 163.55,243.23 v2(163.55,243.68)
  BOTTOM w0.127: R590.1 163.7,244.27 163.55,244.12 v2(163.55,243.68)
WL_MCASP2_ACLKR: length 22.2
  TOP w0.127: U125.13 183.41,217.33 v2(183.92,216.82) ; R51.2 v2(181.23,234.62)
  L08_SIG2 w0.127: v2(183.92,216.82) 181.23,219.52 v2(181.23,234.62)
WL_MCASP2_AXR1: length 28.3
  TOP w0.127: R49.2 178.18,234.62 178.04,234.48 178.04,231.72 185.9,223.87 193.34,223.87 194.44,222.77 194.44,220.56 195,220 U128.13
WL_MCASP2_AXR4: length 31.9
  TOP w0.127: U125.11 184.71,217.69 v2(184.81,217.59) ; R829.2 177.42,233.86 v2(176.66,234.62) R48.2
  L08_SIG2 w0.127: v2(176.66,234.62) 177.79,235.75 181.73,235.75 182.37,235.11 182.37,220.03 v2(184.81,217.59)
WL_MCASP2_FSR: length 22.7
  TOP w0.127: U125.12 184,218.88 184,217.72 v2(184.02,217.69) ; R50.2 v2(179.7,234.62)
  L08_SIG2 w0.127: v2(179.7,234.62) 180.2,235.12 181.43,235.12 181.86,234.69 181.86,219.85 v2(184.02,217.69)
WL_UART1_CTSN: length 32.9
  TOP w0.127: v2(175.26,214.98) 175.26,215.51 172.66,218.11 U126.10 ; R60.2 v2(169.04,234.37)
  L08_SIG2 w0.127: v2(169.04,234.37) 170.27,235.6 174.12,235.6 175.26,234.46 v2(175.26,214.98)
WL_UART1_RTSN: length 26.1
  TOP w0.127: v2(172.16,215.53) 172.16,216.47 171.36,217.27 U126.12 ; R61.2 v2(170.56,234.37)
  L08_SIG2 w0.127: v2(172.16,215.53) 171.85,215.22 170.88,215.22 169.93,216.17 169.93,233.73 v2(170.56,234.37)
WL_UART1_RXD: length 23.4
  TOP w0.127: U126.11 172.01,217.47 v2(173.63,215.85) ; R63.2 v2(173.61,234.37)
  L08_SIG2 w0.127: v2(173.61,234.37) 173.61,233.92 173.63,233.9 v2(173.63,215.85)
WL_UART1_TXD: length 23.4
  TOP w0.127: R62.2 v2(172.08,234.37) ; U126.13 170.71,217.09 171.25,216.55 v2(171.25,215.81)
  L08_SIG2 w0.127: v2(171.25,215.81) 171.25,233.53 v2(172.08,234.37)
WL_WLAN_CLK: length 37
  TOP w0.127: U128.10 v2(196.95,217.36)
  L03_SIG1 w0.127: v2(196.6,246.65) 202.01,241.24 202.01,234.97 202.22,234.76 202.22,233.53 200.99,232.3 200.99,229.12 199.95,228.08 199.95,220.36 v2(196.95,217.36)
  BOTTOM w0.127: R593.1 196.36,246.89 v2(196.6,246.65)
WL_WLAN_EN: length 25.7
  TOP w0.127: R59.2 v2(195.2,234.62) ; v2(194.97,220.87) 194.97,220.49 195.65,219.81 U128.12 195.65,217.36 195.1,216.8 191.91,216.8 191.41,217.3 R138.1 190.87,218.14 190.84,218.11 R638.2
  L03_SIG1 w0.127: v2(195.2,234.62) 195.2,234.18 194.97,233.95 v2(194.97,220.87)
WL_WLAN_IRQ: length 21.5
  TOP w0.127: U125.10 185.36,217.7 v2(185.55,217.52)
  BOTTOM w0.127: v2(185.55,217.52) 185.23,217.83 185.23,222.45 181.86,225.82 181.86,233.6 182.88,234.62 R605.2
WLAN_EN: length 221.2
  TOP w0.127: U51.6 89.36,110.07 89.18,109.9 v2(89.18,109.13) ; U128.5 195.65,214.9 194.61,215.94 192.25,215.94 191.11,214.8 191.11,208.88 187.83,205.6 v2(155.8,205.6)
  BOTTOM w0.127: v2(155.8,205.6) 155.02,206.39 130.81,206.39 122.3,214.9 111.91,214.9 109.73,212.71 109.73,191.46 109.96,191.23 109.96,189.98 107.98,188.01 100.16,188.01 99.41,187.26 99.41,181.44 98.39,180.42 98.39,177.24 99.29,176.34 99.29,161.03 88.14,149.87 88.14,110.17 v2(89.18,109.13)
WLAN_IRQ: length 140.8
  TOP w0.127: U125.7 185.36,212.35 186.26,211.45 186.35,211.45 v2(186.66,211.14) ; v2(208.03,201.82) 212.85,196.99 212.85,196.93 212.98,196.8 212.98,165.78 211.45,164.25 211.45,127.14 204.22,119.9 199.52,119.9 v2(198.96,119.34) ; U1.C15 v1(182.01,117.81)
  L03_SIG1 w0.127: v2(208.03,201.82) 195.99,201.82 v2(186.66,211.14)
  L08_SIG2 w0.102: v1(182.01,117.81) 183.46,117.81 183.64,118 184.4,118 184.66,117.74 189.1,117.74
  L08_SIG2 w0.127: v2(198.96,119.34) 198.64,119.03 198.35,119.03 197.71,118.39 197.71,118.11 195.91,116.31 191.27,116.31 189.84,117.74 189.1,117.74
WLAN_SLOW_CLK: length 192.8
  TOP w0.127: U128.7 196.95,212.13 196.9,212.08 v2(196.9,211.52) ; v2(188.95,99.11) 188.85,99.21 R464.1
  L03_SIG1 w0.127: v2(188.95,99.11) 188.95,98.82 192.26,95.52 195.33,95.52 196.65,94.2 205.53,94.2 205.79,94.45 207.61,94.45 208.81,95.66 211.87,95.66 221.21,104.99 221.52,104.99 227.63,104.99 229.01,106.36 229.01,112.13 v2(228.98,112.16)
  L08_SIG2 w0.127: v2(228.35,131.97) 227.71,131.33 225.93,131.33 225.55,131.71 225.55,135.14 224.18,136.51 224.18,138.13 224.08,138.24 224.08,171.9 228.73,176.54 v2(229.49,176.54) 229.49,180.35 227.56,182.29 227.56,199.63 v2(230.25,202.33)
  BOTTOM w0.127: v2(229.49,176.54) 229.55,176.61 R674.2 ; v2(196.9,211.52) 206.1,202.33 v2(230.25,202.33) ; v2(228.98,112.16) 228.98,129.3 228.47,129.81 228.47,131.84 v2(228.35,131.97)
WLAN_TRANS_EN: length 155.9
  TOP w0.127: U126.14 170.06,220.25 169.93,220.39 169.49,220.39 169.41,220.3 U126.15 v2(169.41,217.34) 169.39,217.31 168.53,217.31 168.37,217.47 R830.1 165.52,217.47 164.85,216.8 164.85,214.39 164.08,213.63 162.43,213.63 161.77,214.29 U144.2 ; v2(198.88,137.63) 199.42,138.17 205.77,138.17 206.55,138.95 206.55,161.46 211.38,166.28 v2(211.38,189.8) ; U125.14 182.8,218.99 182.8,221.05 ; v2(182.11,217.72) U125.15 182.11,220.92 182.24,221.05 182.8,221.05 ; v2(194.64,217.31) 194.35,217.6 194.35,217.61 ; 194.35,217.61 U128.14 194.35,220.14 194.16,220.33 194.16,222.66 193.51,223.31 185.07,223.31 182.8,221.05 ; 194.35,217.61 194.26,217.52 193.85,217.52 193.7,217.67 U128.15
  L03_SIG1 w0.127: v2(182.11,217.72) 181.7,217.31 181.5,217.31 181.48,217.3 181.07,217.3 180.78,217.59 180.78,218.65 179.83,219.6 172.21,219.6 169.95,217.34 v2(169.41,217.34)
  BOTTOM w0.127: v2(194.64,217.31) 195.71,216.25 195.71,204.13 207.59,192.24 207.59,192.22 209.45,190.36 210.82,190.36 v2(211.38,189.8) ; v2(198.88,137.63) 198.88,137.3 198.75,137.17 R393.1
WLAN_TRANS_EN_INV: length 53.5
  TOP w0.127: U142.10 v2(210.36,207.15) ; v2(163.58,217.18) 163.54,217.15 U144.4
  L08_SIG2 w0.127: v2(210.36,207.15) 209.85,207.66 196.88,207.66 192.68,211.85 175.23,211.85 173.46,213.63 167,213.63 163.58,217.06 v2(163.58,217.18)
XDS200_EMU0: length 84.4
  TOP w0.127: R129.2 v2(240.41,108.69)
  L08_SIG2 w0.127: v2(203.1,100.73) 203.15,100.73 203.43,100.45 204.56,100.45 204.87,100.76 205.3,100.76 205.51,100.55 205.51,99.83 205.72,99.62 209.63,99.62 210.14,99.11 211.78,99.11 213.61,97.28 213.61,93.06 213.45,92.89 213.45,91.02 214.74,89.73 215.7,89.73 217.09,88.33 217.09,86.71 218.47,85.33 218.47,84.24 219.15,83.56 219.15,83.07 219.66,82.56 219.66,80.86 219.96,80.56 222.3,80.56 222.91,81.17 222.91,82.56 222.43,83.05 v1(222.2,83.05)
  BOTTOM w0.127: U37.2 221.77,80.58 221.59,80.76 221.59,82.06 221.67,82.13 221.67,82.51 v1(222.2,83.05) ; v2(240.41,108.69) 237.57,108.69 231.63,102.76 228.09,102.76 227.14,101.81 221.81,101.81 221.36,102.25 210.72,102.25 210.08,102.88 207.64,102.88 206.78,102.02 204.39,102.02 v2(203.1,100.73)
XDS200_EMU1: length 80.2
  TOP w0.127: R125.2 v2(242.06,108.69)
  L08_SIG2 w0.127: v2(205.05,100.29) 205.17,100.17 205.17,99.39 205.79,98.77 211.61,98.77 213.37,97 213.37,93.44 213.21,93.27 213.21,90.87 214.6,89.47 215.54,89.47 216.66,88.36 216.66,86.48 217.91,85.23 217.91,83.5 218.16,83.25 218.16,83.05 218.64,82.56 218.64,80.58 218.9,80.33 218.9,77.64 219.58,76.95 v1(220.83,76.95)
  BOTTOM w0.127: U37.5 221.93,78.63 221.06,77.76 221.06,77.18 v1(220.83,76.95) ; v2(242.06,108.69) 241.34,107.96 237.24,107.96 230.05,100.78 226.39,100.78 226.06,101.11 223.22,101.11 222.07,99.96 218.82,99.96 218.01,100.78 207.85,100.78 207.77,100.85 205.41,100.85 205.05,100.49 v2(205.05,100.29)
XDS200_SPI1_CLK: length 16
  TOP w0.127: R136.2 264.54,52.14 265.31,52.9 v2(266.55,52.9) ; U11.6 v2(265.93,62.04) R105.2
  BOTTOM w0.127: v2(265.93,62.04) 266.55,61.43 v2(266.55,52.9)
XDS200_SPI1_SCS[0]: length 19.6
  TOP w0.127: U17.E19 248.25,55.22 249.31,55.22 249.53,55.44 249.53,56.2 250.32,56.99 250.34,56.96 250.39,56.96 250.39,57 v1(250.35,57) ; R101.2 257.25,64.84 v2(257.51,64.58) U11.1
  BOTTOM w0.127: v1(250.35,57) 250.39,57 250.39,56.96 253.59,56.96 256.19,59.55 256.19,63.26 v2(257.51,64.58)
XDS200_SPI1_SIMO: length 30.1
  TOP w0.127: U11.5 v2(265.93,60.77) 266.19,60.52 R111.2 ; U17.G17 v1(247.02,54.05)
  L08_SIG2 w0.102: v1(247.02,54.05) 249.04,54.05 249.55,53.53 250.98,53.53
  L08_SIG2 w0.127: 250.98,53.53 251.33,53.89 257.14,53.89 258.4,52.63 259.36,52.63 259.7,52.97 262.69,52.97 263.27,53.56 263.27,58.11 v2(265.93,60.77)
XDS200_SPI1_SOMI: length 22.5
  TOP w0.127: U11.2 v2(257.51,63.31) R102.1 ; U17.H17 v1(247.02,53.25)
  L03_SIG1 w0.102: 250.75,54.68 248.87,52.8 248.26,52.8 247.81,53.25 v1(247.02,53.25)
  L03_SIG1 w0.127: v2(257.51,63.31) 258.85,61.97 258.85,60.75 257.53,59.43 256.18,59.43 253.54,56.78 252.86,56.78 250.75,54.68
XDS200_SPI1_WPN: length 16.2
  TOP w0.127: U17.F18 247.8,54.83 v1(249.02,54.83) ; U11.3 v2(257.51,62.04)
  L03_SIG1 w0.102: v1(249.02,54.83) 249.45,54.83 250.81,56.19
  L03_SIG1 w0.127: v2(257.51,62.04) 254.41,58.94 254.41,58.51 253.3,57.41 252.03,57.41 250.81,56.19
  BOTTOM w0.127: R626.1 v2(257.51,62.04)
XDS200_SPI_HOLDN: length 3.7
  TOP w0.127: U11.7 266.93,63.31 267.18,63.57 R85.2
XDS200_TDO: length 3.7
  TOP w0.127: R81.2 228.47,94.09 228.6,93.97 228.6,92.47 228.4,92.27 U133.2
XDS_BOOTMODE[0]: length 8.5
  TOP w0.127: R194.1 v2(232.38,41.69) ; U17.U3 v2(235.82,46.05)
  BOTTOM w0.127: R194.1 v2(232.38,41.69) 232.38,42.61 v2(235.82,46.05)
XDS_BOOTMODE[1]: length 8.6
  TOP w0.127: U17.T1 232.64,46.45 229.69,43.5 v2(228.67,43.5) R172.1
  BOTTOM w0.127: R172.1 v2(228.67,43.5)
XDS_BOOTMODE[2]: length 10
  TOP w0.127: U17.T2 234.24,46.07 233.27,46.07 229.18,41.98 v2(228.67,41.98) R178.1
  BOTTOM w0.127: R178.1 v2(228.67,41.98)
XDS_BOOTMODE[3]: length 8.8
  TOP w0.127: R187.1 v2(230.86,41.69) ; U17.T3 v1(235.02,46.05)
  BOTTOM w0.127: v1(235.02,46.05) 231.17,42.2 231.17,42 v2(230.86,41.69) R187.1
XDS_BOOTMODE[4]: length 7.5
  TOP w0.127: U17.R1 230.42,47.25 230.1,46.93 v2(228.67,46.93) R152.2
  BOTTOM w0.127: R152.2 v2(228.67,46.93)
XDS_BOOTMODE[5]: length 8.7
  TOP w0.127: R165.2 v2(228.67,48.58) 230.99,48.58 231.93,47.64 234.23,47.64 U17.R2
  BOTTOM w0.127: R165.2 v2(228.67,48.58)
XDS_BOOTMODE[6]: length 9.8
  TOP w0.127: R169.1 v2(228.67,45.28) 229.59,45.28 231.17,46.85 235.03,46.85 U17.R3
  BOTTOM w0.127: R169.1 v2(228.67,45.28)
XDS_BOOTMODE[7]: length 10.5
  TOP w0.127: U17.P4 235.81,48.45 232.51,48.45 230.99,49.98 v2(228.67,49.98) R143.1
  BOTTOM w0.127: R143.1 v2(228.67,49.98)
XDS_SYS_RESETN: length 92.8
  TOP w0.127: v2(261.54,45.79) 261.8,46.04 R167.1 ; v2(261.83,62.95) 261.83,65.55 263.58,67.3 274.8,67.3 296.25,88.75 296.25,104.14 295.4,104.99 293.24,104.99 292.12,103.87 U2.1
  BOTTOM w0.127: v2(261.54,45.79) 261.86,46.1 265.72,46.1 266.42,46.8 266.42,51.37 265.66,52.14 265.66,59.12 v2(261.83,62.95)
XDS_USB_DM: length 59.9
  TOP w0.102: v2(250.56,50.04) 250.56,49.99 250.25,49.68 250.03,49.68 249.79,49.92 248.47,49.92 248.36,50.03 247.8,50.03 U17.M18
  TOP w0.104: v2(252.98,11.95) 252.75,12.18 252.75,12.43 252.88,12.56 U3.2
  L03_SIG1 w0.102: 247.83,48.82 247.82,48.81
  L03_SIG1 w0.127: 247.83,48.82 248.68,49.67 250.2,49.67 v2(250.56,50.04) ; J1.2 257.37,14.21 256.47,15.11 253.4,15.11 252.76,14.46 252.76,12.18 v2(252.98,11.95) 252.7,11.67 252.7,11.02 252.41,10.73 251.21,10.73 247.4,14.54 247.4,34.84 247.82,35.26 247.82,48.81
XDS_USB_DP: length 59.9
  TOP w0.102: v2(250.56,49.08) 250.56,49.12 250.24,49.44 249.94,49.44 249.69,49.68 248.26,49.68 U17.M19
  TOP w0.104: v2(252.22,11.95) 252.52,12.25 252.52,12.38 252.38,12.52 U3.1
  L03_SIG1 w0.102: 248.1,48.71 248.09,48.69
  L03_SIG1 w0.127: 248.09,48.69 248.09,35.14 247.67,34.72 247.67,14.66 251.32,11 252.29,11 252.42,11.13 252.42,11.75 v2(252.22,11.95) 252.48,12.21 252.48,14.58 253.29,15.38 256.64,15.38 J1.3 ; 248.1,48.71 248.79,49.4 249.63,49.4 249.73,49.29 249.73,48.66 249.83,48.55 250.09,48.55 250.16,48.63 250.16,49.29 250.38,49.5 250.79,49.5 250.93,49.37 250.93,49.16 250.84,49.08 v2(250.56,49.08)
XDS_VBUS: length 48.1
  TOP w0.254: 256.57,14.78 J1.1 255.65,14.49 255.4,14.75 255.4,15.31 255.14,15.57 253.68,15.57 252.38,14.27 U3.6 v2(251.64,13.73)
  L03_SIG1 w0.381: v2(250.7,45.61) 250.16,45.07 250.16,34.13 248.69,32.65 248.69,15.61 250.57,13.73 v2(251.64,13.73)
  BOTTOM w0.381: v2(250.7,45.61) 250.19,46.12 R880.2 ; C8.1 257.42,17.27 256.57,16.42 J1.1
N11645758: length 2.9
  TOP w0.127: U57.5 v2(200.22,24.2)
  BOTTOM w0.127: R735.1 v2(200.22,24.2)
N11646921: length 3
  TOP w0.127: U54.5 v2(220.83,51.27)
  BOTTOM w0.127: v2(220.83,51.27) 219.55,51.27 R726.2
N14027466: length 13.6
  TOP w0.102: 128.05,61.72 124.62,61.72 124.22,62.12 124.62,62.52 128.05,62.52
  TOP w0.127: U82.P5 127.25,62.52 ; 128.05,62.52 U82.N5 ; U82.T6 125.65,61.72 ; 128.05,61.72 U82.N6 ; U82.P6 127.25,61.72 ; U82.R5 126.45,62.52 ; R522.1 124.22,62.12 ; U82.R6 126.45,61.72 ; U82.T5 125.65,62.52
N14027930: length 4
  TOP w0.127: U82.T3 U82.T4 124.97,63.72 124.41,64.28 R517.2
N14056347: length 2.5
  TOP w0.127: U102.36 v2(107.32,42.09)
  BOTTOM w0.127: v2(107.32,42.09) 106.88,41.65 R771.2
N14056377: length 9.2
  TOP w0.127: v2(89.44,27.29) 89.4,27.25 U108.5 89.4,24.95 88.93,24.48 85.01,24.48 84.85,24.64 U108.12
  BOTTOM w0.127: R772.2 v2(89.44,27.29)
N14056401: length 2.5
  TOP w0.127: U102.72 v2(94.95,33.59)
  BOTTOM w0.127: R766.2 95.14,33.39 v2(94.95,33.59)
N14057055: length 2.8
  TOP w0.127: R561.2 100.69,51.04 100.8,51.16 U103.3
N14058041: length 6.9
  TOP w0.127: U102.69 96.09,35.03 94.5,35.03 v2(94.06,34.59)
  BOTTOM w0.127: R758.1 91.87,35.91 92.71,35.07 93.57,35.07 v2(94.06,34.59)
N14060680: length 4
  TOP w0.254: C344.2 279.27,33.67 277.84,35.1 U96.23
N14060684: length 18.2
  TOP w0.254: J33.3 284.71,24.55 C344.1
N14060688: length 3.4
  TOP w0.254: C343.2 275.34,33.77 275.34,33.78 275.34,36.16
N14060756: length 5.4
  TOP w0.254: U96.3 270.05,41.39 268.5,39.84 C328.2
N14060760: length 3.3
  TOP w0.254: C332.2 269.93,39.28 271.03,40.39 U96.5
N14060764: length 24.8
  TOP w0.254: J32.3 271.37,15.86 269.6,17.64 269.6,27.04 268.86,27.78 268.86,35.45 269.93,36.51 C332.1
N14060776: length 42.5
  TOP w0.254: J32.2 278.77,19.28 277.06,17.57 274.78,17.57 273.41,16.19 273.41,12.61 272.57,11.78 269.8,11.78 268.94,12.64 268.94,26.56 268.38,27.12 268.38,36.18 268.5,36.31 C328.1
N14060794: length 40.5
  TOP w0.254: C343.1 275.34,28.93 275.11,28.7 275.11,27.52 275.59,27.04 278.43,27.04 282.12,23.36 282.12,12.41 282.96,11.57 286.28,11.57 286.79,12.08 286.79,14.65 288.57,16.42 291.11,16.42 292.11,17.42 J33.2
N14060830: length 4.9
  TOP w0.254: v2(270.54,40.81) 270.64,40.91 272.09,40.91 U96.4
  BOTTOM w0.254: C687.2 270.26,40.53 v2(270.54,40.81)
N14060838: length 3.5
  TOP w0.254: v2(271.14,39.72) 271.14,39.77 271.29,39.91 272.09,39.91 U96.6
  BOTTOM w0.254: v2(271.14,39.72) 271.91,38.96 C691.2
N14061510: length 2.4
  TOP w0.102: v2(276.18,44.18) 276.34,44.02 276.34,44.01
  TOP w0.127: 276.34,44.01 U96.41
  BOTTOM w0.127: R762.1 276.11,43.64 276.18,43.71 v2(276.18,44.18)
N14084176: length 10.5
  TOP w0.127: J7.11 103.43,206.01 v2(100.71,206.01) 100.2,206.01 99.48,205.29 R133.1
  BOTTOM w0.127: v2(100.71,206.01) 100.71,205.38 99.81,204.48 R639.2
N14086192: length 3.2
  TOP w0.127: MOD1.10 56.43,222.94 57.19,222.18 C32.1
N14091468: length 2.8
  TOP w0.127: R567.1 167.69,48.15 168.42,48.88 U92.48
N14092548: length 6.6
  TOP w0.127: U92.38 168.9,53.88 167.44,55.34 167.44,56.66 166.93,57.16 166.04,57.16 165.93,57.28 R565.2
N14093724: length 11.5
  TOP w0.127: U92.43 168.81,51.38 168.79,51.4 167.72,51.4 166.84,50.52 160.13,50.52 159.2,49.58 Q13.1
N14093756: length 14.5
  BOTTOM w0.127: J31.11 180.19,15.38 181.1,16.3 181.1,20.59 182.5,21.99 184.02,21.99 184.42,22.38 R585.2
N14096877: length 12
  TOP w0.127: SW6.1 SW6.2 99.15,241.09 99.06,241 99.06,239.41 98.93,239.28 97.41,239.28 97.16,239.03 R885.1
N14115400: length 21.4
  TOP w0.127: U14.6 v2(67.24,207.61) ; R154.1 v2(82.17,206.86)
  L03_SIG1 w0.127: v2(67.24,207.61) 67.24,208.78 67.54,209.08 79.95,209.08 v2(82.17,206.86)
  BOTTOM w0.127: R154.1 v2(82.17,206.86)
N14119383: length 2.9
  TOP w0.127: R40.2 v2(23.37,240.01) 23.37,241.17 Q9.1
  BOTTOM w0.127: R40.2 v2(23.37,240.01)
N14119459: length 2.8
  TOP w0.127: LD11.1 24.26,246.08 Q9.3
N14119466: length 2.8
  TOP w0.127: Q10.3 LD12.1
N14119875: length 2.1
  TOP w0.127: R41.1 28.07,240.04 27.88,240.23 Q10.1
N14120120: length 2.9
  TOP w0.127: LD12.2 v2(28.83,249.4)
  BOTTOM w0.127: v2(28.83,249.4) 28.96,249.28 R591.2
