# Allegro board PROC046_REVA_BOARD.brd (continued)
## Nets (continued)
ETHER1_D0N: J31.10(MX0-) U92.3(TXRXM_A) U94.2(D1-)
ETHER1_D0P: J31.9(MX0+) U92.2(TXRXP_A) U94.1(D1+)
ETHER1_D1N: J31.8(MX1-) U92.6(TXRXM_B) U94.5(D2-)
ETHER1_D1P: J31.7(MX1+) U92.5(TXRXP_B) U94.4(D2+)
ETHER1_D2N: J31.6(MX2-) U90.2(D1-) U92.8(TXRXM_C)
ETHER1_D2P: J31.5(MX2+) U90.1(D1+) U92.7(TXRXP_C)
ETHER1_D3N: J31.4(MX3-) U90.5(D2-) U92.11(TXRXM_D)
ETHER1_D3P: J31.3(MX3+) U90.4(D2+) U92.10(TXRXP_D)
FB_DCDC: C29.1 R83.1 R84.1 U6.9(FB_DCDC)
FB_LDO1: R68.1 R608.1 U6.11(FB_LDO1)
FB_LDO2: R44.1 R603.1 U6.14(FB_LDO2)
FLASH_HOLD: R339.1 U1.C18(PR1_PRU1_GPO15/PR1_PRU1_GPI15/G) U40.1(HOLD#/DQ3)
FLASH_RESET#: U33.19(B3) U127.1(A)
FLASH_RSTN_AND: U40.3(RESET#/DNU2) U127.4(Y)
FLASH_WPN: R344.2 U33.17(B5) U40.9(W#/VPP/DQ2)
GATE: C827.1 Q20.1(G) U149.10(GATE)
GP4-0: R91.2 U17.E12(EMA_A[16]/MMCSD0_DAT[5]/GP4[0])
GP4-1: RA13.2 U17.B11(EMA_A[17]/MMCSD0_DAT[4]/GP4[1])
GP4-2: RA13.3 U17.E11(EMA_A[18]/MMCSD0_DAT[3]/GP4[2])
GP4-3: RA13.4 U17.C10(EMA_A[19]/MMCSD0_DAT[2]/GP4[3])
GP4-4: RA13.1 U17.A11(EMA_A[20]/MMCSD0_DAT[1]/GP4[4])
GPIO_EXP_INT: R11.1 U1.A14(PR1_PRU1_GPO0/PR1_PRU1_GPI0/GPI) U51.22(I\N\T\)
HDMI_AC_BIAS_EN: U82.F1(3Y4) U102.33(DE)
HDMI_AUDBCLK: TP213.1(TP) U69.12(1B2) U102.45(SCK) U115.20(B2)
HDMI_AUDD0: TP208.1(TP) U69.10(2B2) U102.41(SD0) U115.18(B4)
HDMI_AUDD1: TP209.1(TP) U102.40(SD1) U115.16(B6)
HDMI_AUDD2: TP210.1(TP) U102.39(SD2) U115.15(B7)
HDMI_AUDD3: TP211.1(TP) U102.37(SD3) U115.14(B8)
HDMI_AUDFSX: TP214.1(TP) U69.11(2B1) U102.44(WS) U115.19(B3)
HDMI_AUDIO_MSTRCLK: R500.2 R537.1 U75.3(OUTPUT)
HDMI_AUDMCLK: TP212.1(TP) U69.13(1B1) U102.38(MCLK) U115.21(B1)
HDMI_CEC: U102.71(CEC_A) U108.1(CEC_A)
HDMI_CEC_D: TP166.1(TP) U102.50(CEC_D)
HDMI_CLK+: J36.10 U102.59(TXC+) U108.16(CLK+)
HDMI_CLK-: J36.12 U102.58(TXC-) U108.15(CLK-)
HDMI_DATA0: U81.A2(1Y1) U102.32(D0)
HDMI_DATA1: U81.A1(1Y2) U102.31(D1)
HDMI_DATA2: U81.B2(1Y3) U102.30(D2)
HDMI_DATA3: U81.B1(1Y4) U102.29(D3)
HDMI_DATA4: U81.C2(2Y1) U102.28(D4)
HDMI_DATA5: U81.C1(2Y2) U102.27(D5)
HDMI_DATA6: U81.D2(2Y3) U102.25(D6)
HDMI_DATA7: U81.D1(2Y4) U102.24(D7)
HDMI_DATA8: U81.E2(3Y1) U102.23(D8)
HDMI_DATA9: U81.E1(3Y2) U102.20(D9)
HDMI_DATA10: U81.F2(3Y3) U102.19(D10)
HDMI_DATA11: U81.F1(3Y4) U102.18(D11)
HDMI_DATA12: U81.G2(4Y1) U102.17(D12)
HDMI_DATA13: U81.G1(4Y2) U102.16(D13)
HDMI_DATA14: U81.H1(4Y3) U102.15(D14)
HDMI_DATA15: U81.H2(4Y4) U102.14(D15)
HDMI_DATA16: U82.A2(1Y1) U102.13(D16)
HDMI_DATA17: U82.A1(1Y2) U102.11(D17)
HDMI_DATA18: U82.B2(1Y3) U102.10(D18)
HDMI_DATA19: U82.B1(1Y4) U102.9(D19)
HDMI_DATA20: U82.C2(2Y1) U102.8(D20)
HDMI_DATA21: U82.C1(2Y2) U102.7(D21)
HDMI_DATA22: U82.D2(2Y3) U102.6(D22)
HDMI_DATA23: U82.D1(2Y4) U102.4(D23)
HDMI_EXTSWING: R765.1 U102.56(EXT_SWING)
HDMI_HPLG: R764.1 U102.54(HPD) U108.4(HPD_A)
HDMI_HSYNC: U82.E1(3Y2) U102.34(HSYNC)
HDMI_I2CSCL: R562.2 U102.49(DSCL) U108.2(SCL_A)
HDMI_I2CSDA: R769.2 U102.48(DSDA) U108.3(SDA_A)
HDMI_INTN: R556.2 U1.A15(PR1_PRU1_GPO5/PR1_PRU1_GPI5/GPI) U102.52(INT)
HDMI_PCLK: U82.E2(3Y1) U102.22(IDCK)
HDMI_RSTN: R274.1 U35.20(B2) U91.1(A)
HDMI_RSTN_AND: U91.4(Y) U102.51(RESET#)
HDMI_TX0+: J36.7 U102.62(TX0+) U108.18(D0+)
HDMI_TX0-: J36.9 U102.61(TX0-) U108.17(D0-)
HDMI_TX1+: J36.4 U102.65(TX1+) U108.21(D1+)
HDMI_TX1-: J36.6 U102.64(TX1-) U108.20(D1-)
HDMI_TX2+: J36.1 U102.68(TX2+) U108.23(D2+)
HDMI_TX2-: J36.3 U102.67(TX2-) U108.22(D2-)
HDMI_VSYNC: U82.F2(3Y3) U102.35(VSYNC)
HDMICONN_CEC: J36.13 U108.7(CEC_B)
HDMICONN_HPLG: J36.19 U108.10(HPD_B)
HDMICONN_I2CSCL: J36.15 U108.8(SCL_B)
HDMICONN_I2CSDA: J36.16 U108.9(SDA_B)
HDR_UART2_RXD: J49.4 U124.4(B2)
HDR_UART2_TXD: J49.5 U124.5(B1)
INA_ALERT: J18.4 R253.1 R788.1 R789.1 R790.1 R791.1 R792.1
INT: U20.M3(PQ7/U1RI) U30.7(2A2)
INT1: U20.W10(PT0/CAN0RX/EN0RXD0/LCDDATA10/T6) U24.9(A7)
JTAG_PD: J7.5 R179.1
JTAG_RTCK: J7.9 R133.2
LCD_BLUE0: J22.21 U81.J2(5Y1)
LCD_BLUE1: J22.22 U81.J1(5Y2)
LCD_BLUE2: J22.23 U81.K2(5Y3)
LCD_BLUE3: J22.24 U81.K1(5Y4)
LCD_BLUE4: J22.25 U81.L2(6Y1)
LCD_BLUE5: J22.26 U81.L1(6Y2)
LCD_BLUE6: J22.27 U81.M2(6Y3)
LCD_BLUE7: J22.28 U81.M1(6Y4)
LCD_DCLK: J22.30 R510.2
LCD_EN: J22.34 R507.2
LCD_GREEN0: J22.13 U81.N2(7Y1)
LCD_GREEN1: J22.14 U81.N1(7Y2)
LCD_GREEN2: J22.15 U81.P2(7Y3)
LCD_GREEN3: J22.16 U81.P1(7Y4)
LCD_GREEN4: J22.17 U81.R2(8Y1)
LCD_GREEN5: J22.18 U81.R1(8Y2)
LCD_GREEN6: J22.19 U81.T1(8Y3)
LCD_GREEN7: J22.20 U81.T2(8Y4)
LCD_HD: J22.32 R509.2
LCD_RED0: J22.5 U82.G2(4Y1)
LCD_RED1: J22.6 U82.G1(4Y2)
LCD_RED2: J22.7 U82.H1(4Y3)
LCD_RED3: J22.8 U82.H2(4Y4)
LCD_RED4: J22.9 U82.J2(5Y1)
LCD_RED5: J22.10 U82.J1(5Y2)
LCD_RED6: J22.11 U82.K2(5Y3)
LCD_RED7: J22.12 U82.K1(5Y4)
LCD_VD: J22.33 R508.2
LDO1_1V8: C152.2 C158.1 C721.1 C722.1 C757.1 C758.2 C813.1 FB9.1 J42.1 R258.1 R381.2 R536.1 R896.1 TP122.1(TP) U32.N6(LDO1) U46.8(VBUS) U46.10(VIN+) U122.6(VCCB) U123.A2(VIN) U142.19(VCCB)
LDO2_1V8: C151.2 C157.1 C812.2 FB8.1 R543.1 TP118.1(TP) U32.N4(LDO2) U142.2(VCCA)
LDO3_1V8: C457.1 C466.2 R856.1 R857.1 TP103.1(TP) U32.E7(LDO3)
LDO4_1V8: C116.1 C121.2 TP100.1(TP) U32.C8(LDO4)
LDO5_3V3: C469.1 C476.2 TP110.1(TP) U32.K1(LDO5)
LDO6_3V3: C163.1 C164.2 TP120.1(TP) U32.M2(LDO6)
LDO7_3V3: C504.2 C505.1 TP121.1(TP) U32.M3(LDO7)
LDO8_3V3: C160.1 C161.2 TP119.1(TP) U32.M1(LDO8)
LDO_PCIE_CAP: C207.1 C575.1 FB22.2 U1.J8(LDO_PCIE_CAP#J8) U1.L8(LDO_PCIE_CAP#L8)
LDO_USB_CAP: C251.1 C631.1 FB30.2 U1.H19(LDO_USB_CAP#H19) U1.J18(LDO_USB_CAP#J18)
LED_MODE: R570.2 TP171.1(TP) U92.41(CLK125_NDO/LED_MODE)
MCASP0AHCLKX_EN: J45.2 U139.1(O\E\)
MEM_A4: RA11.8 U9.J3(A4)
MEM_A5: RA11.7 U9.J2(A5)
MEM_A6: RA11.5 U9.H3(A6)
MEM_A7: RA11.6 U9.H2(A7)
MEM_A8: RA5.6 U9.H1(A8)
MEM_A9: RA5.5 U9.G3(A9)
MEM_A10: RA5.8 U9.H9(A10)
MEM_A11: RA5.7 U9.G2(A11)
MEM_A12: RA12.6 TP40.1(TP)
MEM_BA0: RA12.7 U9.G7(BA0)
MEM_BA1: RA12.5 U9.G8(BA1)
MEM_CASN: R88.1 U9.F7(CAS#)
MEM_CKE: R87.1 U9.F3(CKE)
MEM_CLK: R86.1 U9.F2(CLK)
MEM_CS0N: R94.1 R613.1 U9.G9(CS#)
MEM_D2: RA2.2 U9.B8(DQ2)
MEM_D3: RA2.4 U9.C9(DQ3)
MEM_D4: RA4.1 U9.C8(DQ4)
MEM_D5: RA4.2 U9.D9(DQ5)
MEM_D6: RA4.3 U9.D8(DQ6)
MEM_D7: RA4.4 U9.E9(DQ7)
MEM_D8: RA3.1 U9.E1(DQ8)
MEM_D9: RA3.2 U9.D2(DQ9)
MEM_D10: RA3.3 U9.D1(DQ10)
MEM_D11: RA3.4 U9.C2(DQ11)
MEM_D12: RA1.1 U9.C1(DQ12)
MEM_D13: RA1.3 U9.B2(DQ13)
MEM_D14: RA1.2 U9.B1(DQ14)
MEM_D15: RA1.4 U9.A2(DQ15)
MEM_RASN: R92.1 U9.F8(RAS#)
MEM_WE_DQM0N: R619.1 U9.E8(DQML)
MEM_WE_DQM1N: R620.1 U9.F1(DQHM)
MFP0: R535.2 R755.2 U96.45(MFP0)
MFP1: R534.2 R756.2 U96.46(MFP1)
MFP2: TP164.1(TP) U96.47(MFP2)
MFP3: TP165.1(TP) U96.48(MFP3)
MIPI_EMU02: J19.13 RA18.13
MIPI_EMU03: J19.17 RA18.11
MIPI_EMU04: J19.23 RA18.14
MIPI_EMU05: J19.25 RA18.16
MIPI_EMU06: J19.27 RA18.9
MIPI_EMU07: J19.29 RA18.15
MIPI_EMU08: J19.31 RA18.10
MIPI_EMU09: J19.33 RA18.12
MIPI_EMU10: J19.35 RA19.14
MIPI_EMU11: J19.37 RA19.12
MIPI_EMU12: J19.39 RA19.15
MIPI_EMU13: J19.41 RA19.16
MIPI_EMU14: J19.43 RA19.11
MIPI_EMU15: J19.45 RA19.13
MIPI_EMU16: J19.47 RA19.10
MIPI_EMU17: J19.49 RA19.9
MIPI_EMU18: J19.51 RA17.8
MIPI_EMU19: J19.53 RA17.7
MIPI_EMU_RTCK: J19.7 R329.1
MIPI_RTCK: R329.2 U132.16(B6)
MIPI_TCK: R314.1 R322.2 R326.2 U132.3(A1) U132.8(A6)
MIPI_TCK_R: J19.3 R322.1
MIPI_TDI: R327.2 U132.4(A2)
MIPI_TDI_R: J19.5 R327.1
MIPI_TDO: R362.1 U133.3(IA1)
MIPI_TDO_R: J19.4 R362.2
MIPI_TMS: R358.1 U132.6(A4)
MIPI_TMS_R: J19.2 R358.2
MIPI_TRGRSTZ: R781.1 R904.2 U132.9(A7)
MIPI_TRST#: R364.1 U132.5(A3)
MIPI_TRST#_R: J19.8 R364.2
MLB_RSTN: R300.1 U35.14(B8) U106.1(A)
MLB_RSTN_AND: J34.25 R854.1 U140.4(Y)
MODE: R75.2 R611.1 U6.7(MODE)
NRESPWRON2: R245.2 R248.1 U20.A13(PQ4/DIVSCLK/U1RX) U26.3(B)
OSCIN: C60.1 U17.L19(OSCIN) Y2.3
OSCOUT: C54.1 U17.K19(OSCOUT) Y2.1
OSCVSS: C54.2 C60.2 R635.1 U17.L18(OSCVSS) Y2.2(GND1) Y2.4(GND2)
PCI_CON_PORZ: J44.2 R606.2
PCI_PORZ_IN: J44.1 R855.1 U131.4(Y)
PCI_PORZ_OUT: J44.3 R884.1 U138.1(A)
PCIE_CLKN_CML_100MHZ: R20.2 U1.F2(PCIE_CLK_N)
PCIE_CLKN_HCSL_100MHZ: J5.A14 R732.1 R891.2
PCIE_CLKP_CML_100MHZ: R19.2 U1.G2(PCIE_CLK_P)
PCIE_CLKP_HCSL_100MHZ: J5.A13 R734.1 R890.2
PCIEI_RSTN: R65.1 R288.1 U35.15(B7)
PGD: R924.1 R925.1 U149.8(NPGD)
PHY1_LED_ACTN: J31.12 R528.1 R751.1 U92.17(LED1 / PME_N1/PHYAD0)
PHY1_LED_LINKN: J31.13 R530.1 R752.1 U92.15(LED2/PHYAD1)
PLL0_VDDA1V2: C79.2 C416.1 FL13.2 U17.L15(PLL0_VDDA)
PLL0_VSSA: C79.1 C416.2 FL14.2 U17.M17(PLL0_VSSA)
PLL1_VDDA1V2: C94.2 C459.1 FL16.2 U17.N15(PLL1_VDDA)
PLL1_VSSA: C94.1 C459.2 FL15.2 U17.M15(PLL1_VSSA)
PLL_LOCK: U20.R3(PH4/U0DTR) U62.46(STATUS0)
PMBUS_I2C_EN: U14.5(EN) U20.V16(PK6/EN0LED1/EN0TXD2/EPI0S25/I2C)
PMBUS_SCL: R118.2 R370.2 R709.2 U42.5(SCL) U43.5(SCL) U44.5(SCL) U46.2(A0) U46.5(SCL) U48.5(SCL)
PMBUS_SDA: R117.2 R371.2 R374.2 U42.4(SDA) U43.4(SDA) U44.2(A0) U44.4(SDA) U46.4(SDA) U48.4(SDA)
PMIC_GPIO2: R330.2 R703.2 R851.2 R907.2
PMIC_HDRST: D12.1(K) SW8.1(A1) SW8.2(A2) U32.L6(HDRST)
PMIC_PGOOD: TP85.1(TP) U32.C4(PGOOD)
PMIC_PWRHOLD: J13.2 U32.N1(PWRHOLD)
PMIC_PWRON: D13.1(K) R334.2 SW9.1(A1) SW9.2(A2) U32.E4(PWRON)
PMIC_VDD1: C110.2 C111.2 C718.1 C719.1 J41.1 L5.2 R360.2 U32.D4(VFB1) U44.8(VBUS) U44.10(VIN+)
PMIC_VDD2: C130.2 C148.2 C149.2 C428.2 C442.1 C443.1 C444.1 C445.1 C448.1 C449.1 C450.1 C456.1 C462.1 C465.1 C474.1 C475.1 C477.1 C478.1 C488.1 C489.1 C490.1 C491.1 C494.1 C495.1 C496.1 C501.1 C502.1 C503.1 C506.1 C507.1 C508.1 C509.1 C511.1 C512.1 C513.1 C514.1 C515.1 C516.1 C517.1 C522.1 C523.1 C524.1 C528.1 C529.1 C530.1 C531.1 C541.1 C542.1 C543.1 C544.1 C546.1 C547.1 C548.1 C555.1 C559.1 C563.1 C568.1 C569.1 C570.1 C571.1 C579.1 C580.1 C581.1 C582.1 C583.1 C584.1 C589.1 C602.1 C603.1 C604.1 C605.1 C606.1 C607.1 C608.1 C724.1 C725.1 J43.1 L7.2 R383.2 R723.2 TP113.1(TP) U25.5(VDDQ) U27.A2(VDD#A2) U27.A9(VDD#A9) U27.B9(VDDQ#B9) U27.C1(VDDQ#C1) U27.D7(VDD#D7) U27.E2(VDDQ#E2) U27.E9(VDDQ#E9) U27.G2(VDD#G2) U27.G8(VDD#G8) U27.K1(VDD#K1) U27.K9(VDD#K9) U27.M1(VDD#M1) U27.M9(VDD#M9) U32.K2(VFB2) U39.A2(VDD#A2) U39.A9(VDD#A9) U39.B9(VDDQ#B9) U39.C1(VDDQ#C1) U39.D7(VDD#D7) U39.E2(VDDQ#E2) U39.E9(VDDQ#E9) U39.G2(VDD#G2) U39.G8(VDD#G8) U39.K1(VDD#K1) U39.K9(VDD#K9) U39.M1(VDD#M1) U39.M9(VDD#M9) U45.A2(VDD#A2) U45.A9(VDD#A9) U45.B9(VDDQ#B9) U45.C1(VDDQ#C1) U45.D7(VDD#D7) U45.E2(VDDQ#E2) U45.E9(VDDQ#E9) U45.G2(VDD#G2) U45.G8(VDD#G8) U45.K1(VDD#K1) U45.K9(VDD#K9) U45.M1(VDD#M1) U45.M9(VDD#M9) U48.8(VBUS) U48.10(VIN+) U49.A2(VDD#A2) U49.A9(VDD#A9) U49.B9(VDDQ#B9) U49.C1(VDDQ#C1) U49.D7(VDD#D7) U49.E2(VDDQ#E2) U49.E9(VDDQ#E9) U49.G2(VDD#G2) U49.G8(VDD#G8) U49.K1(VDD#K1) U49.K9(VDD#K9) U49.M1(VDD#M1) U49.M9(VDD#M9) U52.A2(VDD#A2) U52.A9(VDD#A9) U52.B9(VDDQ#B9) U52.C1(VDDQ#C1) U52.D7(VDD#D7) U52.E2(VDDQ#E2) U52.E9(VDDQ#E9) U52.G2(VDD#G2) U52.G8(VDD#G8) U52.K1(VDD#K1) U52.K9(VDD#K9) U52.M1(VDD#M1) U52.M9(VDD#M9)
PMIC_VDD_CTRL: C101.1 C715.1 C716.1 J40.1 L4.2 R357.2 U43.8(VBUS) U43.10(VIN+)
PMIC_VIO: C141.2 C142.2 L6.2 R330.1 R345.1 R346.1 R900.2 U32.H8(VFBIO) U32.N7(VDDIO)
PORN: R249.1 U24.16(B6) U26.1(A)
PRSNT1#: R596.1 U1.AB23(GPMC_CLK/GPIO0_16)
PRSNT#: J5.A1 R594.1 R595.1
PWRON_RSTZ: D7.1(K) J9.1 R224.1 SW5.1(A1) SW5.2(A2) U20.D8(PP4/OWIRE/U0DSR/U3RTS/USB0D7)
QSPI_RSTN: R273.1 U35.21(B1) U71.1(A)
QSPI_RSTN_AND: U71.4(Y) U72.3(RESET#/RFU)
RS232_CONN0_RX: P1.2 U93.13(RIN1)
RS232_CONN0_TX: P1.3 U93.14(DOUT1)
RS232_RX: J6.4 U13.8(RIN)
RS232_TX: J6.3 U13.13(DOUT)
RSV6_TOGGLE: R927.2 U33.21(B1)
RTC_XI: C52.1 U17.J19(RTC_XI) Y1.2
RTC_XO: C53.1 U17.H19(RTC_XO) Y1.1
RTCK/GP8[0]: R141.2 U17.K17(RTCK/GP8[0])
SD_LP2996A: R311.1 U1.E25(SPI3_SCSN1/PR0_UART0_RXD/GPIO0_)
SEC_REFN: R493.2 U62.12(SEC_REFN)
SEC_REFP: R496.2 U62.11(SEC_REFP)
SEL_HDMIN: R520.1 R521.1 SW13.2 U51.16(P16) U81.A3(\1\O\E\) U81.A4(\2\O\E\) U81.H3(\4\O\E\) U81.H4(\3\O\E\) U82.A3(\1\O\E\) U82.A4(\2\O\E\) U82.H4(\3\O\E\)
SEL_HDMIN_GPIO: R521.2 U1.G22(MII_CRS/RMII_CRS_DV/GPIO0_84)
SEL_LCD: R728.1 R807.1 R809.1 SW14.2 U80.2(A)
SEL_LCDN: R471.2 U51.17(P17) U80.4(Y) U81.J3(\5\O\E\) U81.J4(\6\O\E\) U81.T3(\8\O\E\) U81.T4(\7\O\E\) U82.H3(\4\O\E\) U82.J3(\5\O\E\) U82.J4(\6\O\E\)
SEL_LCDN_GPIO: R807.2 U1.B14(PR1_PRU1_GPO1/PR1_PRU1_GPI1/GPI)
SEL_XDS: U37.15(E\) U41.22(O\E\) U47.4(Y) U133.1(S) U134.1(S)
SEL_XDS200_INV: J19.58 R391.1 R717.2 U47.2(A) U132.22(O\E\)
SOC_ARM_BENDIAN: U20.J18(PL3/C1O/EPI0S19/IDX0/USB0D3) U66.9(A2)
SOC_ARM_LENDIAN: U20.U19(PK4/EN0INTRN/EN0LED0/EN0RXD3/EP) U66.8(A1)
SOC_BACKLIGHT_PWM: Q12.1(G) R429.2 U1.E18(PR1_MDIO_DATA/GPIO1_46/ECAP0_IN)
SOC_BOOTCOMPLETE: R379.2 U1.Y3(BOOTCOMPLETE) U20.B13(PP2/EPI0S29/U0DTR/USB0NXT)
SOC_CPTS_TS_COMP: R816.2 U1.C21(UART2_RTSN/PR1_EDIO_DATA0/UART0)
SOC_DCAN0_RX: C314.1 J26.2 R545.1 U1.R5(DCAN0_RX/GPIO1_57)
SOC_DCAN0_TX: R544.1 U1.P5(DCAN0_TX/GPIO1_56)
SOC_DCAN1_RX: C313.1 J25.2 R540.1 U1.H21(QSPI_CSN3/DCAN1_RX/PR1_UART0_RT)
SOC_DCAN1_TX: R539.1 U1.H22(QSPI_CSN2/DCAN1_TX/PR1_UART0_CT)
SOC_DSS_DE: R512.2 U1.M25(DSS_DE/GPMC_A0/PR1_EDIO_OUTVALI)
SOC_DSS_FID: TP157.1(TP) U1.L25(DSS_FID/PR0_EDIO_OUTVALID/GPIO0)
SOC_DSSDATA0: RA10.1 U1.V22(DSS_DATA0/GPMC_A1/GPIO0_53/DSS_)
SOC_DSSDATA1: RA10.2 U1.U21(DSS_DATA1/GPMC_A2/EQEP2_S/GPIO0)
SOC_DSSDATA2: RA10.3 U1.W22(DSS_DATA2/GPMC_A3/EQEP2_I/GPIO0)
SOC_DSSDATA3: RA10.4 U1.V23(DSS_DATA3/GPMC_A4/EQEP2_B/GPIO0) U66.4(B2)
SOC_DSSDATA4: RA7.1 U1.U23(DSS_DATA4/GPMC_A5/EQEP2_A/GPIO0)
SOC_DSSDATA5: RA7.2 U1.V24(DSS_DATA5/GPMC_A6/EQEP1_S/GPIO0) U66.5(B1)
SOC_DSSDATA6: RA7.3 RA17.2 U1.T21(DSS_DATA6/GPMC_A7/EQEP1_I/GPIO0)
SOC_DSSDATA7: RA7.4 RA17.1 U1.U22(DSS_DATA7/GPMC_A8/EQEP1_B/GPIO0)
SOC_DSSDATA8: RA9.1 RA19.8 U1.T22(DSS_DATA8/GPMC_A9/EQEP1_A/GPIO0) U67.23(2B8)
SOC_DSSDATA9: RA9.2 RA19.7 U1.R21(DSS_DATA9/GPMC_A10/EQEP0_S/GPIO) U67.22(2B7)
SOC_DSSDATA10: RA9.5 RA19.4 U1.U24(DSS_DATA10/GPMC_A11/EQEP0_I/GPI) U67.17(2B4)
SOC_DSSDATA11: RA9.3 RA19.6 U1.V25(DSS_DATA11/GPMC_A12/EQEP0_B/GPI) U67.20(2B6)
SOC_DSSDATA12: RA9.8 RA19.1 U1.T24(DSS_DATA12/GPMC_A13/EQEP0_A/GPI) U67.13(2B1)
SOC_DSSDATA13: RA9.7 RA19.2 U1.P21(DSS_DATA13/GPMC_A14/EHRPWM_TZN2) U67.14(2B2)
SOC_DSSDATA14: RA9.4 RA19.5 U1.U25(DSS_DATA14/GPMC_A15/EHRPWM2_B/G) U67.19(2B5)
SOC_DSSDATA15: RA9.6 RA19.3 U1.R22(DSS_DATA15/GPMC_A16/EHRPWM2_A/G) U67.16(2B3)
SOC_DSSDATA16: RA8.4 RA18.5 U1.P23(DSS_DATA16/GPMC_A17/EHRPWM_TZN1) U67.8(1B5)
SOC_DSSDATA17: RA8.2 RA18.7 U1.R24(DSS_DATA17/GPMC_A18/EHRPWM1_B/G) U67.11(1B7)
SOC_DSSDATA18: RA8.7 RA18.2 U1.N22(DSS_DATA18/GPMC_A19/EHRPWM1_A/G) U67.3(1B2)
SOC_DSSDATA19: RA8.1 RA18.8 U1.T25(DSS_DATA19/GPMC_A20/EHRPWM0_SYN) U67.12(1B8)
SOC_DSSDATA20: RA8.8 RA18.1 U1.N24(DSS_DATA20/GPMC_A21/EHRPWM0_SYN) U67.2(1B1)
SOC_DSSDATA21: RA8.6 RA18.3 U1.P24(DSS_DATA21/GPMC_A22/EHRPWM_TZN0) U67.5(1B3)
SOC_DSSDATA22: RA8.3 RA18.6 U1.P25(DSS_DATA22/GPMC_A23/EHRPWM0_B/G) U67.9(1B6)
SOC_DSSDATA23: RA8.5 RA18.4 U1.N23(DSS_DATA23/GPMC_A24/EHRPWM0_A/G) U67.6(1B4)
SOC_DSSHSYNC: R514.2 U1.P22(DSS_HSYNC/GPMC_A26/PR1_ECAP0_EC)
SOC_DSSPCLK: R513.2 U1.N25(DSS_PCLK/GPMC_A27/PR1_ECAP0_ECA)
SOC_DSSVSYNC: R511.2 U1.R25(DSS_VSYNC/GPMC_A25/PR1_ECAP0_EC)
SOC_ECAP1_IN_PWM1_OUT: J12.42 U1.D18(PR1_MDIO_MDCLK/GPIO1_47/ECAP1_I)
SOC_EHRPWM3_SYNCI: J12.39 U1.C22(EHRPWM3_SYNCI/PR0_EDIO_DATA1/GP)
SOC_EHRPWM3_SYNCO: J12.41 U1.D23(EHRPWM3_SYNCO/PR0_EDIO_DATA0/GP)
SOC_EHRPWM3A: J12.33 U1.A23(EHRPWM3_A/PR0_EDIO_DATA3/GPIO0_)
SOC_EHRPWM3B: J12.35 U1.B22(EHRPWM3_B/PR0_EDIO_DATA2/GPIO0_)
SOC_EHRPWM4A: J12.45 U1.D12(PR1_PRU0_GPO18/PR1_PRU0_GPI18/P)
SOC_EHRPWM4B: J12.47 U1.D13(PR1_PRU0_GPO19/PR1_PRU0_GPI19/P)
SOC_EHRPWM5A: J12.34 U1.E17(PR1_PRU1_GPO18/PR1_PRU1_GPI18/P)
SOC_EHRPWM5B: J12.36 U1.E16(PR1_PRU1_GPO19/PR1_PRU1_GPI19/P)
SOC_EHRPWM_TRIPZONE_INPUT3: J12.37 U1.H24(MII_TXER/PR0_ECAP0_ECAP_SYNCIN/)
SOC_EHRPWM_TRIPZONE_INPUT4: J12.46 U1.E13(PR1_PRU0_GPO17/PR1_PRU0_GPI17/G)
SOC_EHRPWM_TRIPZONE_INPUT5: J12.38 U1.F16(PR1_PRU1_GPO17/PR1_PRU1_GPI17/G)
SOC_EMU00: J19.19 R350.2 R351.2 U37.4(YA)
SOC_EMU01: J19.21 R352.2 R355.2 U37.7(YB)
SOC_GPIO0_102: U1.P4(SPI2_SCSN1/GPIO0_102) U20.H4(PQ2/EPI0S22/SSI3XDAT0/T7CCP0)
SOC_GPMC_AD0: U1.AC21(GPMC_AD0/GPIO0_00) U87.29(I/O0)
SOC_GPMC_AD1: U1.AE20(GPMC_AD1/GPIO0_01) U87.30(I/O1)
SOC_GPMC_AD2: U1.AD22(GPMC_AD2/GPIO0_02) U87.31(I/O2)
SOC_GPMC_AD3: U1.AD20(GPMC_AD3/GPIO0_03) U87.32(I/O3)
SOC_GPMC_AD4: U1.AE21(GPMC_AD4/GPIO0_04) U87.41(I/O4)
SOC_GPMC_AD5: U1.AE22(GPMC_AD5/GPIO0_05) U87.42(I/O5)
SOC_GPMC_AD6: U1.AC20(GPMC_AD6/GPIO0_06) U87.43(I/O6)
SOC_GPMC_AD7: U1.AD21(GPMC_AD7/GPIO0_07) U87.44(I/O7)
SOC_GPMC_AD8: U1.AE23(GPMC_AD8/GPIO0_08) U87.26(I/O8)
SOC_GPMC_AD9: U1.AB20(GPMC_AD9/GPIO0_09) U87.27(I/O9)
SOC_GPMC_AD10: U1.AA20(GPMC_AD10/GPIO0_10) U87.28(I/O10)
SOC_GPMC_AD11: U1.AD23(GPMC_AD11/GPIO0_11) U87.33(I/O11)
SOC_GPMC_AD12: U1.AA21(GPMC_AD12/GPIO0_12) U87.40(I/O12)
SOC_GPMC_AD13: U1.AB21(GPMC_AD13/GPIO0_13) U87.45(I/O13)
SOC_GPMC_AD14: U1.AB22(GPMC_AD14/GPIO0_14) U87.46(I/O14)
SOC_GPMC_AD15: U1.AA22(GPMC_AD15/GPIO0_15) U87.47(I/O15)
SOC_GPMC_ALE: U1.AC23(GPMC_ADVN_ALE/GPIO0_17) U87.17(ALE)
SOC_GPMC_CLE: U1.AC24(GPMC_BEN0_CLE/GPIO0_20) U87.16(CLE)
SOC_GPMC_CSN0: U1.AB25(GPMC_CSN0/GPIO0_26) U87.9(C\E\)
SOC_GPMC_RE#: U1.AC22(GPMC_OEN_REN/GPIO0_18) U87.8(R\E\)
SOC_GPMC_WAIT0: R761.2 U1.Y24(GPMC_WAIT0/GPIO0_22) U87.7(R/B\)
SOC_GPMC_WE#: U1.Y22(GPMC_WEN/GPIO0_19) U87.18(W\E\)
SOC_GPMC_WP#: R760.2 U1.W25(GPMC_WPN/GPIO0_24) U87.19(W\P\)
SOC_I2C0_SCL: J12.28 R366.1 R700.2 R705.2 R800.2 U16.2(SCLA)
SOC_I2C0_SDA: J12.30 R265.2 R365.1 R706.2 R801.2 U16.3(SDAA)
SOC_I2C1_SCL: J21.3 R377.2 R553.2 R710.1 R803.1 U51.19(SCL) U96.1(SCL) U102.1(CSCL) U112.1(SCL)
SOC_I2C1_SDA: J21.4 R376.2 R558.2 R711.1 R804.1 U51.20(SDA) U96.2(SDA) U102.2(CSDA) U112.6(SDA)
SOC_I2C2_SCL: R324.1 R369.2 R707.1 R814.2
SOC_I2C2_SDA: R325.1 R368.2 R708.1 R815.2
SOC_I2C_EN: U16.5(EN) U20.V17(PK5/EN0LED2/EN0RXD2/EPI0S31/I2C)
SOC_INT: U1.N3(SPI1_SCSN1/GPIO0_100) U30.10(2B2)
SOC_LED0: R428.1 R819.2
SOC_LED1: R462.1 R818.2
SOC_LED2: LD4.1 U51.5(P04)
SOC_LED3: LD2.1 U51.4(P03)
SOC_LED4: LD5.1 U51.3(P02)
SOC_LRESETNMIENZ: U1.V1(LRESETNMIENN) U24.20(B2)
SOC_LRESETZ: U1.V2(LRESETN) U24.21(B1)
SOC_MCASP0ACLKR: JP1.59 R470.1
SOC_MCASP0ACLKX: JP1.81 R452.1 U115.4(A2)
SOC_MCASP0AHCLKR: JP1.54 R473.1
SOC_MCASP0AHCLKX: R408.1 R458.1 U139.2(A)
SOC_MCASP0AMUTE: JP1.30 R444.1
SOC_MCASP0AXR0: JP1.53 R482.1 U115.6(A4)
SOC_MCASP0AXR1: JP1.69 R454.1 U115.8(A6)
SOC_MCASP0AXR2: JP1.60 R451.1 U115.9(A7)
SOC_MCASP0AXR3: JP1.76 R447.1 U115.10(A8)
SOC_MCASP0AXR4: JP1.57 R480.1
SOC_MCASP0AXR5: JP1.45 R476.1
SOC_MCASP0AXR6: JP1.77 R472.1
SOC_MCASP0AXR7: JP1.52 R469.1
SOC_MCASP0AXR8: JP1.82 R441.1
SOC_MCASP0AXR9: JP1.83 R437.1
SOC_MCASP0AXR10: R462.2 R820.2 U1.E11(PR1_PRU0_GPO5/PR1_PRU0_GPI5/MMC)
SOC_MCASP0AXR10_R: JP1.78 R820.1
SOC_MCASP0AXR12: JP1.71 R459.1
SOC_MCASP0AXR13: JP1.63 R481.1
SOC_MCASP0AXR14: JP1.65 R460.1
SOC_MCASP0AXR15: JP1.72 R477.1
SOC_MCASP0FSR: JP1.64 R468.1
SOC_MCASP0FSX: JP1.66 R448.1 U115.5(A3)
SOC_MCASP1ACLKR: JP1.33 R398.1
SOC_MCASP1ACLKX: JP1.34 R405.1
SOC_MCASP1AHCLKR: JP1.42 R402.1
SOC_MCASP1AMUTE: R817.2 R823.2 U1.A5(PR0_PRU0_GPO19/PR0_PRU0_GPI19/P)
SOC_MCASP1AMUTE_R: JP1.27 R823.1
SOC_MCASP1AXR0: JP1.29 R439.1
SOC_MCASP1AXR1: JP1.36 R434.1
SOC_MCASP1AXR2: JP1.47 R430.1
SOC_MCASP1AXR3: JP1.40 R425.1
SOC_MCASP1AXR4: JP1.39 R422.1
SOC_MCASP1AXR5: JP1.75 R419.1
SOC_MCASP1AXR6: JP1.46 R416.1
SOC_MCASP1AXR7: JP1.58 R414.1
SOC_MCASP1AXR8: JP1.35 R412.1
SOC_MCASP1AXR9: JP1.51 R410.1
SOC_MCASP1FSR: JP1.41 R394.1
SOC_MCASP1FSX: JP1.28 R404.1
SOC_MCASP2ACLKR: JP1.23 R401.1
SOC_MCASP2ACLKX: R413.1 U64.13(1B1) U136.4(1A1)
SOC_MCASP2AHCLKR: R407.1 U56.3(CLK_OUT)
SOC_MCASP2AHCLKX: JP1.48 R417.1
SOC_MCASP2AMUTE: R393.2 R822.2 U1.C2(PR0_PRU0_GPO9/PR0_PRU0_GPI9/XRE)
SOC_MCASP2AMUTE_R: JP1.21 R822.1
SOC_MCASP2AXR0: R428.2 R821.2 U1.D3(PR0_PRU0_GPO0/PR0_PRU0_GPI0/GPI)
SOC_MCASP2AXR0_R: JP1.22 R821.1
SOC_MCASP2AXR1: R423.1 U135.3(A)
SOC_MCASP2AXR2: R433.1 U136.6(2A1)
SOC_MCASP2AXR3: R415.1 U137.4(B)
SOC_MCASP2AXR4: R396.1 U64.11(2B1)
SOC_MCASP2AXR5: JP1.24 R420.1
SOC_MCASP2FSR: JP1.18 R409.1
SOC_MCASP2FSX: R411.1 U64.12(1B2) U136.5(1A2)
SOC_MCBSPCLKR: J12.29 U1.D17(PR1_PRU1_GPO14/PR1_PRU1_GPI14/M)
SOC_MCBSPCLKX: J12.25 U1.B16(PR1_PRU1_GPO12/PR1_PRU1_GPI12/M)
SOC_MCBSPDR: J12.19 U1.D15(PR1_PRU1_GPO9/PR1_PRU1_GPI9/MCB)
SOC_MCBSPDX: J12.21 U1.A16(PR1_PRU1_GPO10/PR1_PRU1_GPI10/M)
SOC_MCBSPFSR: J12.27 U1.C16(PR1_PRU1_GPO13/PR1_PRU1_GPI13/M)
SOC_MCBSPFSX: J12.23 U1.E15(PR1_PRU1_GPO11/PR1_PRU1_GPI11/M)
SOC_MDIO_CLK: R767.2 U1.U3(MDIO_CLK/GPIO0_98) U92.36(MDC)
SOC_MDIO_DATA: R770.2 U1.V3(MDIO_DATA/GPIO0_97) U92.37(MDIO)
SOC_MLB_GPIO2: J34.24 U1.C14(PR1_PRU1_GPO2/PR1_PRU1_GPI2/GPI)
SOC_MLB_PCLKN: J27.2 J34.17 R572.2 R773.1 U1.L23(MLBP_CLK_N)
SOC_MLB_PCLKP: J27.1 J34.19 R571.2 R773.2 U1.M23(MLBP_CLK_P)
SOC_MLB_PDATDN: J28.2 J34.9 R574.2 R775.1 U1.K22(MLBP_DAT_N)
SOC_MLB_PDATDP: J28.1 J34.11 R573.2 R775.2 U1.K23(MLBP_DAT_P)
SOC_MLB_PSIGN: J29.2 J34.1 R576.2 R774.1 U1.M24(MLBP_SIG_N)
SOC_MLB_PSIGP: J29.1 J34.3 R575.2 R774.2 U1.L24(MLBP_SIG_P)
SOC_MLBCLK: J34.2 J48.3 U1.AA24(GPMC_WAIT1/MLB_CLK/GPIO0_23)
SOC_MLBDAT: J34.10 J48.1 U1.W24(GPMC_CSN1/MLB_DAT/GPIO0_27)
SOC_MLBSIG: J34.6 J48.2 U1.AA25(GPMC_DIR/MLB_SIG/GPIO0_25)
SOC_MMC0_CLK: R436.2 U1.F13(PR1_PRU0_GPO15/PR1_PRU0_GPI15/M)
SOC_MMC0_CLK_R: J37.5(CLK) R242.1 R436.1 U111.3(IO3)
SOC_MMC0_CMD: R432.2 U1.C13(PR1_PRU0_GPO16/PR1_PRU0_GPI16/M)
SOC_MMC0_CMD_R: J37.3(CMD) R432.1 R780.1 U111.6(IO4)
SOC_MMC0_DAT0: R427.2 U1.B13(PR1_PRU0_GPO14/PR1_PRU0_GPI14/M)
SOC_MMC0_DAT0_R: J37.7(DAT0) R427.1 R779.1 U111.2(IO2)
SOC_MMC0_DAT1: R424.2 U1.A13(PR1_PRU0_GPO13/PR1_PRU0_GPI13/M)
SOC_MMC0_DAT1_R: J37.8(DAT1) R424.1 R777.1 U111.1(IO1)
SOC_MMC0_DAT2: R418.2 U1.A11(PR1_PRU0_GPO12/PR1_PRU0_GPI12/M)
SOC_MMC0_DAT2_R: J37.1(DAT2) R418.1 R776.1 U111.8(IO6)
SOC_MMC0_DAT3: R421.2 U1.A12(PR1_PRU0_GPO11/PR1_PRU0_GPI11/M)
SOC_MMC0_DAT3_R: J37.2(CD/DAT3) R421.1 R778.1 U111.7(IO5)
SOC_MMC0_SDCD: J37.9(CD1) R577.1 U1.F12(PR1_PRU0_GPO6/PR1_PRU0_GPI6/MMC) U107.3(IO1)
SOC_MMC1_CLK: R388.2 R713.2 U1.J4(MMC1_CLK/GPIO0_67)
SOC_MMC1_CLK_R: R388.1 R681.1
SOC_MMC1_CMD: R387.2 R714.2 U1.J2(MMC1_CMD/GPIO0_68)
SOC_MMC1_CMD_R: R287.1 R387.1 R687.1
SOC_MMC1_DAT0: RA6.1 RA15.1 U1.H3(MMC1_DAT0/GPIO0_66)
SOC_MMC1_DAT0_R: R292.1 R688.2 RA6.8
SOC_MMC1_DAT1: RA6.2 RA15.2 U1.F5(MMC1_DAT1/GPIO0_65)
SOC_MMC1_DAT1_R: R281.1 R682.2 RA6.7
SOC_MMC1_DAT2: RA6.3 RA15.3 U1.J5(MMC1_DAT2/GPIO0_64)
SOC_MMC1_DAT2_R: R269.1 R679.2 RA6.6
SOC_MMC1_DAT3: RA6.4 RA15.4 U1.H4(MMC1_DAT3/GPIO0_63)
SOC_MMC1_DAT3_R: R304.1 R695.2 RA6.5
SOC_MMC1_DAT4: R299.1 R691.2 U1.E3(MMC1_DAT4/GPIO0_62)
SOC_MMC1_DAT5: R286.1 R685.2 U1.G4(MMC1_DAT5/GPIO0_61)
SOC_MMC1_DAT6: R271.1 R680.2 U1.F4(MMC1_DAT6/GPIO0_60)
SOC_MMC1_DAT7: R260.1 R673.2 U1.G5(MMC1_DAT7/GPIO0_59)
SOC_MMC1_SDWP: R676.1 U1.K3(MMC1_SDWP/GPIO0_70)
SOC_NMIZ: R229.2 R665.1 U1.W1(NMIN) U24.19(B3)
SOC_PCIE_RXN0: J5.A16 R182.2
SOC_PCIE_RXN0_C: R182.1 U1.D1(PCIE_RXN0)
SOC_PCIE_RXP0: J5.A17 R181.2
SOC_PCIE_RXP0_C: R181.1 U1.E1(PCIE_RXP0)
SOC_PCIE_TXN0: C171.2 J5.B14
SOC_PCIE_TXN0_C: C171.1 U1.H1(PCIE_TXN0)
SOC_PCIE_TXP0: C170.2 J5.B15
SOC_PCIE_TXP0_C: C170.1 U1.G1(PCIE_TXP0)
SOC_PCIE_WAKEN: J5.B11 R802.2 U1.E14(PR1_PRU1_GPO3/PR1_PRU1_GPI3/GPI)
SOC_PLL_LOCK: R39.2 U1.N5(OBSPLL_LOCK) U20.B12(PP5/I2C2SCL/OWALT/U3CTS/USB0D6)
SOC_PORZ: R259.2 U1.AA3(PORN) U26.4(Y)
SOC_QSPI_CLK: R463.2 U1.K25(QSPI_CLK/GPIO1_58)
SOC_QSPI_CLK_R: R463.1 R740.1 R877.2
SOC_QSPI_CSN0: R745.2 U1.J25(QSPI_CSN0/GPIO1_64) U72.7(CS#)
SOC_QSPI_D0: U1.J23(QSPI_D0/GPIO1_60) U72.15(SI/IO0)
SOC_QSPI_D1: U1.J22(QSPI_D1/GPIO1_61) U72.8(SO/IO1)
SOC_QSPI_D2: R746.2 U1.J21(QSPI_D2/GPIO1_62) U72.9(WP#/IO2)
SOC_QSPI_D3: R743.2 U1.J24(QSPI_D3/GPIO1_63) U72.1(HOLD#/IO3)
SOC_QSPI_RTCLK: R740.2 U1.K24(QSPI_RCLK/GPIO1_59)
SOC_RESETFULLZ: R883.1 U24.18(B4) U138.3(B)
SOC_RESETFULLZ_AND: R881.1 U1.W2(RESETFULLN) U138.4(Y)
SOC_RESETSTATZ: JP1.11 R42.2 R378.2 U1.Y2(RESETSTATN) U5.2(B) U20.C12(PP3/EPI0S30/RTCCLK/U0DCD/U1CTS/) U36.2(B) U58.2(B) U71.2(B) U89.2(B) U91.2(B) U97.2(B) U106.2(B) U127.2(B)
SOC_RESETZ: R238.1 U23.3(B) U24.17(B5)
SOC_RESETZ_AND: R239.1 U1.W3(RESETN) U23.4(Y)
SOC_RGMII_RXCLK: R560.1 U1.A22(MII_RXCLK/RGMII_RXC/GPIO0_72)
SOC_RGMII_RXCLK_R: R559.1 R560.2 R768.1 U92.35(RX_CLK/PHYAD2)
SOC_RGMII_RXCTL: R554.1 U1.A24(MII_RXDV/RGMII_RXCTL/GPIO0_81)
SOC_RGMII_RXCTL_R: R552.1 R554.2 R763.1 U92.33(RX_DV/CLK125_EN)
SOC_RGMII_RXD0: R549.1 U1.B24(MII_RXD0/RGMII_RXD0/RMII_RXD0/G)
SOC_RGMII_RXD0_R: R548.1 R549.2 R759.1 U92.32(RXD0/MODE0)
SOC_RGMII_RXD1: R546.1 U1.C23(MII_RXD1/RGMII_RXD1/RMII_RXD1/G)
SOC_RGMII_RXD1_R: R541.1 R546.2 R757.1 U92.31(RXD1/MODE1)
SOC_RGMII_RXD2: R538.1 U1.B23(MII_RXD2/RGMII_RXD2/GPIO0_78)
SOC_RGMII_RXD2_R: R533.1 R538.2 R754.1 U92.28(RXD2/MODE2)
SOC_RGMII_RXD3: R532.1 U1.F22(MII_RXD3/RGMII_RXD3/GPIO0_77)
SOC_RGMII_RXD3_R: R531.1 R532.2 R753.1 U92.27(RXD3/MODE3)
SOC_RGMII_TXCLK: R449.1 U1.C25(MII_TXCLK/RGMII_TXC/GPIO0_85)
SOC_RGMII_TXCLK_R: R449.2 U92.24(GTX_CLK)
SOC_RGMII_TXCTL: R465.1 U1.H25(MII_TXEN/RGMII_TXCTL/RMII_TXEN/)
SOC_RGMII_TXCTL_R: R465.2 U92.25(TX_EN)
SOC_RGMII_TXD0: R445.1 U1.G23(MII_TXD0/RGMII_TXD0/RMII_TXD0/G)
SOC_RGMII_TXD0_R: R445.2 U92.19(TXD0)
SOC_RGMII_TXD1: R467.1 U1.G24(MII_TXD1/RGMII_TXD1/RMII_TXD1/G)
SOC_RGMII_TXD1_R: R467.2 U92.20(TXD1)
SOC_RGMII_TXD2: R466.1 U1.G25(MII_TXD2/RGMII_TXD2/GPIO0_92)
SOC_RGMII_TXD2_R: R466.2 U92.21(TXD2)
SOC_RGMII_TXD3: R453.1 U1.D25(MII_TXD3/RGMII_TXD3/GPIO0_91)
SOC_RGMII_TXD3_R: R453.2 U92.22(TXD3)
SOC_SPI0_CLK: J12.13 R373.1
SOC_SPI0_MISO: J12.9 U1.M1(SPI0_SOMI)
SOC_SPI0_MOSI: J12.11 U1.N4(SPI0_SIMO)
SOC_SPI0_SCS0: J12.15 U1.M3(SPI0_SCSN0)
SOC_SPI0_SCS1: J12.10 U1.M4(SPI0_SCSN1/GPIO0_99)
SOC_SPI1_CLK: R715.2 U1.N2(SPI1_CLK)
SOC_SPI1_CLK_R: R715.1 U40.16(C)
SOC_SPI1_MISO: U1.N1(SPI1_SOMI) U40.8(DQ1)
SOC_SPI1_MOSI: U1.P2(SPI1_SIMO) U40.15(DQ0)
SOC_SPI1_SCS0: R333.2 U1.P1(SPI1_SCSN0) U40.7(S#)
SOC_SPI2_CLK: JP1.9 R716.1
SOC_SPI2_MISO: JP1.16 U1.R4(SPI2_SOMI/GPIO0_104)
SOC_SPI2_MOSI: JP1.15 U1.R3(SPI2_SIMO/GPIO0_105)
SOC_SPI2_SCS0: JP1.17 U1.P3(SPI2_SCSN0/GPIO0_101)
SOC_SPI3_CLK: R450.2 U79.6(SCLK)
SOC_SPI3_MISO: TP159.1(TP) U1.F25(SPI3_SOMI/PR0_UART0_CTSN/GPIO0_)
SOC_SPI3_MOSI: U1.F24(SPI3_SIMO/PR0_UART0_RTSN/GPIO0_) U79.7(DIN)
SOC_SPI3_SCS0: R828.1 U1.C24(SPI3_SCSN0/PR0_ECAP0_ECAP_CAPIN)
SOC_SPI3_SCS0_R: R828.2 U79.5(S\Y\N\C\)
SOC_SYSCLKN: R22.2 U1.AC25(SYSCLK_N)
SOC_SYSCLKP: R21.2 U1.AD25(SYSCLK_P)
SOC_SYSCLKSEL: R262.2 R675.1 U1.R1(SYSCLKSEL) U33.14(B8)
SOC_TCK: U1.L3(TCK) U134.4(YA)
SOC_TDI: R336.2 U1.L5(TDI) U134.7(YB)
SOC_TDO: R328.2 U1.K5(TDO) U59.3(A)
SOC_TIMI1: J12.22 U1.W23(GPMC_CSN2/TIMI1/GPIO0_28)
SOC_TIMO1: J12.24 U1.Y25(GPMC_CSN3/TIMO1/GPIO0_29)
SOC_TMS: R343.2 U1.K4(TMS) U134.12(YD)
SOC_TRST#: R319.2 U1.L4(TRSTN) U134.9(YC)
SOC_UART0_CP2105_EN: U86.4(Y) U146.2(O\E\)
SOC_UART0_CTSN: J12.16 U1.T2(UART0_CTSN/TIMI0/GPIO0_106)
SOC_UART0_RTSN: J12.18 U1.U1(UART0_RTSN/TIMO0/GPIO0_107)
SOC_UART0_RXD: J12.14 U1.T4(UART0_RXD) U146.9(A2) U147.9(A2)
SOC_UART0_TXD: J12.12 U1.T1(UART0_TXD) U146.8(A1) U147.8(A1)
SOC_UART1_CTSN: U1.U2(UART1_CTSN/GPIO1_50) U126.7(2A2)
SOC_UART1_RTSN: U1.U4(UART1_RTSN/GPIO1_51) U126.5(1A2)
SOC_UART1_RXD: U1.T3(UART1_RXD/GPIO1_48) U126.6(2A1)
SOC_UART1_TXD: U1.T5(UART1_TXD/GPIO1_49) U126.4(1A1)
SOC_UART2_DETECT: U68.4(Y) U124.2(O\E\)
SOC_UART2_RXD: U1.E21(UART2_RXD/PR1_EDIO_DATA3/UART0_) U76.5(B1) U124.9(A2)
SOC_UART2_TXD: U1.D21(UART2_TXD/PR1_EDIO_DATA2/UART0_) U76.4(B2) U124.8(A1)
SOC_USB0_DM: L12.1 U1.B18(USB0_DM)
SOC_USB0_DP: L12.4 U1.A18(USB0_DP)
SOC_USB0_ID: R440.2 U1.A19(USB0_ID)
SOC_USB0_VBUSEN: R727.2 U1.E19(USB0_DRVVBUS) U54.4(EN)
SOC_USB0_XO: R489.2 U1.D19(USB0_XO)
SOC_USB1_DM: L11.1 U1.A20(USB1_DM)
SOC_USB1_DP: L11.4 U1.B20(USB1_DP)
SOC_USB1_ID: R446.1 U1.E20(USB1_ID)
SOC_USB1_VBUSEN: R736.2 U1.B21(USB1_DRVVBUS) U57.4(EN)
SOC_USB1_XO: R488.2 U1.C20(USB1_XO)
SOC_VPP_EN: R833.1 U122.4(B) U123.B2(ON)
SPARE0: TP37.1(TP) U12.20(I/O_13)
SPARE1: TP38.1(TP) U12.19(I/O_12)
T_RTCK: R80.2 R783.2 U41.16(B6)
T_SRST_N: R122.2 R905.2 U41.9(A7)
T_TCK: R144.2 U41.3(A1) U41.8(A6)
T_TDI: R147.2 U41.4(A2)
T_TDIS: R72.1 R77.2 R889.2 TP36.1(TP)
T_TMS: R146.2 R643.2 U41.6(A4)
T_TRST_N: R145.2 U41.5(A3)
TDI: J5.A6 R38.2
TEMP_INT: U1.B15(PR1_PRU1_GPO7/PR1_PRU1_GPI7/GPI) U112.3(ALERT)
TMS: J5.A8 R43.2
TOUCH_INTN: J21.5 R729.2 U1.D16(PR1_PRU1_GPO16/PR1_PRU1_GPI16/G)
TPS65000_PG#: R67.1 TP29.1(TP) U4.2(A) U6.3(P\G\)
TPS_INT1: R341.2 U1.F23(MII_RXER/RMII_RXER/GPIO0_82)
TPS_SLEEP: U1.B25(MII_COL/GPIO0_83) U32.F1(SLEEP)
TRANS_EMMC_RSTN: R267.1 U34.4(B)
TRGRSTZ: R348.2 U20.A8(PP7/AIN22/OWIRE) U23.1(A) U41.15(B7) U132.15(B7)
TSC_WAKEN: R277.1 U35.17(B5) U58.1(A)
TSC_WAKEN_AND: J21.6 U58.4(Y)
UART0_TXVR_EN: R435.2 U1.D22(UART2_CTSN/PR1_EDIO_DATA1/UART0) U147.2(O\E\)
UEMU0: R129.1 U12.33(I/O_23)
UEMU1: R125.1 U12.32(I/O_22)
UEXP0: R121.1 U12.29(I/O_19)
UEXP1: R114.1 U12.28(I/O_18)
UEXP2: R110.1 U12.27(I/O_17)
UEXP3: R104.1 U12.23(I/O_16)
URTCK: R80.1 U12.22(I/O_15)
USB0_CONN_DM: D15.1(D+) J35.2 L12.2
USB0_CONN_DP: D15.2(D-) J35.3 L12.3
USB0_VDDA12: C417.1 U17.N17(USB0_VDDA12)
USB0_VDDA18: C73.1 C78.1 C413.1 C415.2 FL5.3(OUTPUT) U17.N14(USB0_VDDA18)
USB0_VDDA33: C64.1 C66.1 C408.2 C412.1 FL3.3(OUTPUT) U17.N18(USB0_VDDA33)
USB1_CONN_DM: D14.1(D+) J38.2(D-) L11.2
USB1_CONN_DP: D14.2(D-) J38.3(D+) L11.3
USB1_CONN_ID: J38.4(ID) R446.2 R584.2 U109.3(ID)
USRSTN: R122.1 U12.31(I/O_21)
UTCK: R144.1 U12.34(I/O_24)
UTDI: R147.1 U12.38(I/O_27)
UTDIS: C386.1 R77.1 U12.18(I/O_11)
UTDO: R81.1 U12.21(I/O_14)
UTMS: R146.1 U12.37(I/O_26)
UTMSK: R643.1 U12.30(I/O_20)
UTRSTN: R145.1 U12.36(I/O_25)
VBACKUP: J17.2 U32.D7(VBACKUP)
VCAN0: C347.1 C353.1 C753.1 P2.9 U100.8(VCC2) U118.7(+VOUT)
VCAN1: C345.1 C352.1 C755.1 P3.9 U98.8(VCC2) U119.7(+VOUT)
VCNTL0: R814.1 U1.Y1(RSV13)
VCNTL1: R815.1 U1.AA1(RSV14)
VCNTL2: TP140.1(TP) U1.AB1(RSV15)
VCNTL3: TP133.1(TP) U1.AA2(RSV16)
VCNTL4: TP139.1(TP) U1.AB2(RSV17)
VCNTL5: TP136.1(TP) U1.AC1(RSV18)
VCOM_BAT: C21.1 C27.1 FB2.1 R82.1 U8.3(OUT1) U8.4(OUT2)
VCOM_BAT_FB: C361.1 C362.1 FB2.2 J2.5 J2.7
VCOM_BATEN: R69.2 R609.2 U8.8(EN)
VCOM_BATFB: C27.2 R73.1 R82.2 U8.5(NR/FB)
VCTCXO_20M: C274.1 U60.5(RFOUTPUT) U62.8(PRI-REFP)
VER0: R97.1 R623.2 U17.C4(AXR[12]/GP0[4])
VER1: R96.1 R624.2 U17.B3(AXR[13]/GP0[5])
VER2: R98.1 R622.2 U17.B4(AXR[14]/GP0[6])
VER3: R99.1 R621.2 U17.A4(AXR[15]/GP0[7])
VETH1_AVDDH: C341.1 C342.1 C346.1 FB11.2 Q13.3(S) U92.1(AVDDH#1) U92.12(AVDDH#12) U92.47(NC2)
VETH1_AVDDL: C333.1 C337.1 FB40.2 U92.4(AVDDL#4) U92.9(AVDDL#9)
VETH1_AVDDL_PLL: C340.1 C685.1 C686.1 FB36.2 U92.44(AVDDL_PLL)
VETH1_AVDDL_PMOS: C327.1 FB36.1 FB37.1 FB40.1 Q13.2(D1) Q13.4(D2)
VETH1_DVDDH: C310.1 C312.1 C672.2 C673.1 D4.1(K) R527.2 R530.2 R531.2 R533.2 R541.2 R552.2 R559.2 R565.1 R566.1 R570.1 R585.1 R586.1 R751.2 R759.2 R767.1 R770.1 U88.5(VCC) U89.5(VCC) U92.16(DVDDH#16) U92.34(DVDDH#34) U92.40(DVDDH#40)
VETH1_DVDDL: C329.1 C330.1 FB37.2 U92.14(DVDDL#14) U92.18(DVDDL#18) U92.23(DVDDL#23) U92.26(DVDDL#26) U92.30(DVDDL#30) U92.39(DVDDL#39)
VHDMI_AVCC12: C319.1 C683.1 C684.1 FB35.1 U102.60(AVCC12_1) U102.66(AVCC12_2)
VHDMI_CVCC12: C689.1 C694.1 C698.1 C700.1 FB39.1 U102.5(CVCC12_1) U102.12(CVCC12_2) U102.26(CVCC12_3) U102.42(CVCC12_4) U102.47(CVCC12_5) U102.53(CVCC12_6)
VHDMI_IOVCC: C325.1 C693.1 C701.1 FB38.1 R556.1 R562.1 R766.1 R769.1 U102.3(IOVCC1) U102.21(IOVCC2) U102.46(IOVCC3)
VLED+: C235.1 C734.1 J22.2 TP152.1(TP) U53.9(OUT)
VLED-: J22.1 R438.1 U53.5(FB)
VOL+: D6.1(K) R168.1 SW2.1(A1) SW2.2(A2) U20.E3(PQ0/EPI0S20/SSI3CLK/T6CCP0)
VOL-: D8.1(K) R196.1 SW4.1(A1) SW4.2(A2) U20.E2(PQ1/EPI0S21/SSI3FSS/T6CCP1)
VPP1V8: C759.2 C760.1 U1.W21(VPP2) U1.Y21(VPP1) U123.A1(VOUT)
VPP_EN: U20.W16(PK7/EN0TXD3/EPI0S24/I2C4SDA/M0F) U122.3(A)
VRTC: C439.1 C446.2 J13.1 R294.1 R668.1 R888.2 TP84.1(TP) U32.B5(VRTC)
VUSB_VBUS0: C350.1 FB45.2 J14.1 J35.1
VUSB_VBUS1: C354.2 C355.1 FB47.2 J30.1 J38.1(VCC) U109.6(VBUS)
WARMRSTZ: D11.1(K) R313.1 SW10.1(A1) SW10.2(A2) U20.D7(PP1/C2-/SSI3XDAT3/T6CCP1/U6TX)
WL_BT_EN: R139.1 R590.1 R637.2 U128.11(2B1)
WL_MCASP2_ACLKR: R51.2 U125.13(1B1)
WL_MCASP2_AXR1: R49.2 U128.13(1B1)
WL_MCASP2_AXR4: R48.2 R829.2 U125.11(2B1)
WL_MCASP2_FSR: R50.2 U125.12(1B2)
WL_UART1_CTSN: R60.2 U126.10(2B2)
WL_UART1_RTSN: R61.2 U126.12(1B2)
WL_UART1_RXD: R63.2 U126.11(2B1)
WL_UART1_TXD: R62.2 U126.13(1B1)
WL_WLAN_CLK: R593.1 U128.10(2B2)
WL_WLAN_EN: R59.2 R138.1 R638.2 U128.12(1B2)
WL_WLAN_IRQ: R605.2 U125.10(2B2)
WLAN_EN: U51.6(P05) U128.5(1A2)
WLAN_IRQ: U1.C15(PR1_PRU1_GPO8/PR1_PRU1_GPI8/GPI) U125.7(2A2)
WLAN_SLOW_CLK: R464.1 R674.2 U128.7(2A2)
WLAN_TRANS_EN: R393.1 R830.1 U125.14(2\O\E\) U125.15(1\O\E\) U126.14(2\O\E\) U126.15(1\O\E\) U128.14(2\O\E\) U128.15(1\O\E\) U144.2(A)
WLAN_TRANS_EN_INV: U142.10(OE) U144.4(Y)
XDS200_EMU0: R129.2 U37.2(IA0)
XDS200_EMU1: R125.2 U37.5(IB0)
XDS200_SPI1_CLK: R105.2 R136.2 U11.6(SCK)
XDS200_SPI1_SCS[0]: R101.2 U11.1(C\E\) U17.E19(S\P\I\1\_\S\C\S\[0]\/GP2[14]/TM)
XDS200_SPI1_SIMO: R111.2 U11.5(SIO) U17.G17(SPI1_SIMO/GP2[10])
XDS200_SPI1_SOMI: R102.1 U11.2(SO) U17.H17(SPI1_SOMI/GP2[11])
XDS200_SPI1_WPN: R626.1 U11.3(W\P\) U17.F18(S\P\I\1\_\S\C\S\[1]\/GP2[15]/TM)
XDS200_SPI_HOLDN: R85.2 U11.7(H\O\L\D\)
XDS200_TDO: R81.2 U133.2(IA0)
XDS_BOOTMODE[0]: R194.1 R658.2 U17.U3(GP7[0]/BOOT[0])
XDS_BOOTMODE[1]: R172.1 R653.2 U17.T1(GP7[1]/BOOT[1])
XDS_BOOTMODE[2]: R178.1 R654.2 U17.T2(GP7[2]/BOOT[2])
XDS_BOOTMODE[3]: R187.1 R657.2 U17.T3(GP7[3]/BOOT[3])
XDS_BOOTMODE[4]: R152.2 R644.1 U17.R1(GP7[4]/BOOT[4])
XDS_BOOTMODE[5]: R165.2 R649.1 U17.R2(GP7[5]/BOOT[5])
XDS_BOOTMODE[6]: R169.1 R651.2 U17.R3(GP7[6]/BOOT[6])
XDS_BOOTMODE[7]: R143.1 R642.2 U17.P4(GP7[7]/BOOT[7])
XDS_SYS_RESETN: R167.1 U2.1(R\E\S\E\T)
XDS_USB_DM: J1.2(D-) U3.2(D-) U17.M18(USB0_DM)
XDS_USB_DP: J1.3(D+) U3.1(D+) U17.M19(USB0_DP)
XDS_VBUS: C8.1 FB3.1 J1.1(VBUS) R35.2 R597.1 R880.2 U3.6(VBUS)
N11645758: R735.1 U57.5(O\C\)
N11646921: R726.2 U54.5(O\C\)
N14027466: R522.1 U82.N5(7A1) U82.N6(7A2) U82.P5(7A3) U82.P6(7A4) U82.R5(8A1) U82.R6(8A2) U82.T5(8A4) U82.T6(8A3)
N14027930: R517.2 U82.T3(\8\O\E\) U82.T4(\7\O\E\)
N14056347: R771.2 U102.36(SPDIF)
N14056377: R772.2 U108.5(LS_OE) U108.12(CT_HPD)
N14056401: R766.2 U102.72(CI2CA)
N14057055: R561.2 U103.3(EN)
N14058041: R758.1 U102.69(IO_SEL)
N14060680: C344.2 U96.23(HPROUT)
N14060684: C344.1 J33.3(T)
N14060688: C343.2 U96.18(HPLOUT)
N14060756: C328.2 U96.3(LINE1L+)
N14060760: C332.2 U96.5(LINE1R+)
N14060764: C332.1 J32.3(T)
N14060776: C328.1 J32.2(TS)
N14060794: C343.1 J33.2(TS)
N14060830: C687.2 U96.4(LINE1L-)
N14060838: C691.2 U96.6(LINE1R-)
N14061510: R762.1 U96.41(DOUT)
N14084176: J7.11 R133.1 R639.2
N14086192: C32.1 MOD1.10(VOUT)
N14091468: R567.1 U92.48(ISET)
N14092548: R565.2 U92.38(INT_N / PME_N2)
N14093724: Q13.1(G) U92.43(LDO_O)
N14093756: J31.11 R585.2
N14096877: R885.1 SW6.1(A1) SW6.2(A2)
N14115400: R154.1 R645.2 U14.6(SDAB)
N14119383: Q9.1(G) R40.2 R602.1
N14119459: LD11.1 Q9.3(D)
N14119466: LD12.1 Q10.3(D)
N14119875: Q10.1(G) R41.1
N14120120: LD12.2 R591.2
N14120305: LD11.2 R592.2
N14152075: J11.2 U20.P19(VBAT)
N14152267: C91.1 C425.2 U20.E10(VDDC#E10) U20.H16(VDDC#H16)
N16781633: R426.1 R721.1 U53.3(SS)
N16781680: Q12.3(D) R721.2
N16781762: R725.2 U53.6(EN)
N16781794: R456.2 U53.7(FSW)
N16801982: R547.1 U93.12(ROUT1)
N16801984: R542.2 U93.11(DIN1)
N16802002: C675.2 U93.6(V-)
N16802018: C688.2 U93.1(C1+)
N16802020: C688.1 U93.3(C1-)
N16802026: C680.2 U93.5(C2-)
N16802028: C680.1 U93.4(C2+)
N16802060: C331.1 U93.2(V+)
N16863485: R693.2 U27.H8(ZQ)
N16909238: R704.2 U39.H8(ZQ)
N16911821: R712.2 U45.H8(ZQ)
N16958621: C239.2 U62.40(REG_CAP)
N16958654: TP158.1(TP) U62.45(STATUS1/PIN0)
N16974283: C238.1 R461.2
N17012640: C278.1 U56.6(XTO) Y7.2
N17012642: C271.1 U56.7(XTI/REF_CLK) Y7.1
N17104917: J2.35 TP17.1(TP)
N17104924: J2.39 TP18.1(TP)
N17105134: J2.62 TP14.1(TP)
N17105148: J2.48 TP15.1(TP)
N17105158: J2.50 TP16.1(TP)
N17108888: R94.2 U17.A18(E\M\A\_\C\S\[0]\/GP2[0])
N17108899: R88.2 U17.A9(E\M\A\_\C\A\S\/GP2[4])
N17108922: R616.2 U17.B15(E\M\A\_\O\E\/GP3[10])
N17108924: R618.2 U17.B9(E\M\A\_\W\E\/GP3[11])
N17109149: R90.1 U17.E9(MMCSD0_CLK/GP4[7])
N17109151: R89.1 U17.A10(EMA_A[22]/MMCSD0_CMD/GP4[6])
N17109206: R93.2 U17.B16(E\M\A\_\C\S\[5]\/GP3[12])
N17109930: R619.2 U17.C8(E\M\A\_\W\E\N\_\D\Q\M\[0]\/GP2[)
N17109932: R620.2 U17.A5(E\M\A\_\W\E\N\_\D\Q\M\[1]\/GP2[)
N17110905: R86.2 U17.B7(EMA_CLK/GP2[7])
N17110913: R87.2 U17.D8(EMA_SDCKE/GP2[6])
N17110918: R92.2 U17.A16(E\M\A\_\R\A\S\/GP2[5])
N17113205: R189.2 U17.V2(GP7[12])
N17118481: R108.2 R110.2 TP41.1(TP)
N17118483: R104.2 R115.2 TP39.1(TP)
N17118485: R95.2 R121.2 TP46.1(TP)
N17118487: R107.2 R114.2 TP44.1(TP)
N17119674: J1.4(ID) R34.2
N17124284: C234.1 U1.AC19(SYSOSC_IN) Y6.1
N17124300: C232.1 U1.AE19(SYSOSC_OUT) Y6.3
N17138453: R113.1 U12.26(VCCIO2)
N17150258: J19.12 R879.2
N17177920: R231.1 R667.1 U20.W4(PA5/I2C7SDA/SSI0XDAT1/T2CCP1/U3)
N17193198: LD7.2 R32.1
N17193212: LD8.1 Q7.3(D)
N17193213: LD7.1 Q6.3(D)
N17193222: LD6.2 R31.1
N17217348: J19.6 R781.2
N17217726: C168.1 R314.2
N17219428: J19.15 R342.2
N17224206: LD8.2 R33.1
N17253655: R116.2 TP43.1(TP)
N17253657: R116.1 U17.C5(AXR[11]/GP0[3])
N17253714: R128.2 TP49.1(TP)
N17253716: R128.1 U17.E4(AXR[8]/GP0[0])
N17253732: R120.1 U17.C3(AXR9/GP0[1])
N17253734: R120.2 TP45.1(TP)
N17253750: R124.1 U17.D4(AXR[10]/GP0[2])
N17253752: R124.2 TP47.1(TP)
N17255053: R127.1 U17.F16(S\P\I\1\_\S\C\S\[4]\/UART2_TXD/)
N17255055: R127.2 TP48.1(TP)
N17255071: R130.1 U17.F17(S\P\I\1\_\S\C\S\[5]\/UART2_RXD/)
N17255073: R130.2 TP50.1(TP)
N17255146: R136.1 U17.G19(SPI1_CLK/GP2[13])
N17255876: R158.1 U17.P16(USB0_ID)
N17277948: C296.1 C665.2 FL8.3 U78.2(VIN)
N17278529: C666.1 U78.5(TRIM/NR)
N17278696: C303.1 U78.6(VOUT) U79.2(VREF)
N17279260: C292.1 C293.2 FL9.3 U79.1(VDD)
N17280261: C272.2 C273.1 FL7.3 U60.9(VCC)
N17280894: R119.1 U17.B18(EMA_WAIT[0]/GP3[8])
N17280896: R123.1 U17.B19(EMA_WAIT[1]/GP2[1])
N17286145: TP65.1(TP) U17.T18(CLKOUT/GP6[14])
N17286149: R185.1 TP82.1(TP) U17.T17(RESETOUT/GP6[15])
N17289768: R156.2 R167.2 R650.2 U17.K14(R\E\S\E\T\)
N17289805: C407.2 R149.1
N17289822: R640.1 U17.J17(RSVDN)
N17291112: C277.1 R486.1 R487.1 U60.10(VC)
N17296373: TP57.1(TP) U17.T19(RSV2)
N17428402: R719.1 U1.H7(PCIE_REFRES)
N17473267: R509.1 U82.L1(6Y2)
N17484568: R813.2 U115.2(DIR)
N17556024: R670.1 U32.A6(DRVL)
N17556030: C452.2 U22.4(TGR) U32.A4(SW)
N17556082: R244.1 U32.B3(TRIP)
N17556602: C452.1 U32.A2(VBST)
N17556776: R671.2 U22.3(TG)
N17556786: L5.1 U32.D1(SW1_C) U32.D2(SW1_B) U32.E2(SW1_A)
N17556798: L7.1 U32.H1(SW2_B) U32.H2(SW2_A)
N17556884: R671.1 U32.A3(DRVH)
N17556932: C451.1 U32.C5(VFB)
N17557226: TP91.1(TP) U32.C6(TRAN)
N17557396: TP102.1(TP) U32.D5(EN)
N17557440: L6.1 U32.K7(SWIO_B) U32.K8(SWIO_A)
N17557462: R670.2 U22.5(BG)
N17557538: R692.2 U32.E8(VCCS)
N17601404: D2.4(REF) R599.1 R600.2
N17601690: U2.3(M\R\) U4.4(Y)
N17601710: C363.1 U2.4(CT)
N17628247: L2.1 U6.5(SW)
N17734901: C14.1 D5.1(CATHODE) L1.1 U7.8(SW)
N17856438: TP106.1(TP) U27.A7(NF/TDQS#)
N17856470: TP115.1(TP) U39.A7(NF/TDQS#)
N17856498: TP123.1(TP) U45.A7(NF/TDQS#)
N17944399: R347.2 TP125.1(TP) U1.J3(MMC1_SDCD/GPIO0_69)
N17944408: TP124.1(TP) U1.K2(MMC1_POW/GPIO0_71)
N18024893: R153.1 R646.2 U14.7(SCLB)
N18029281: R170.2 U20.A5(PE4/AIN9/SSI1XDAT0/U1RI)
N18029296: R177.2 U20.B5(PE5/AIN8/SSI1XDAT1)
N18031024: R109.1 U10.3(VEN)
N18055312: TP169.1(TP) U96.7(LINE2L+)
N18055326: TP170.1(TP) U96.8(LINE2L-)
N18055702: TP172.1(TP) U96.19(HPLCOM)
N18055705: TP173.1(TP) U96.22(HPRCOM)
N18067178: R558.1 U95.6(SDAB)
N18067322: R563.1 R564.2 U95.5(EN)
N18068201: TP168.1(TP) U96.35(GPIO1)
N18068219: TP167.1(TP) U96.34(GPIO2)
N18091435: R435.1 R749.1 SW12.2 U86.2(A)
N18114221: TP182.1(TP) U20.F17(PT3/CAN1TX/LCDDATA19/T7CCP1)
N18124845: R694.2 U34.5(DIR)
N18144573: R316.1 R699.2 U35.2(DIR)
N18147498: R310.1 R696.2 U33.2(DIR)
N18151943: R255.1 R672.2 U24.2(DIR)
N18158148: R280.1 R683.2 U30.2(1DIR)
N18158579: R290.1 R689.2 U30.3(2DIR)
N18163620: R232.1 R666.1 U20.V4(PA4/I2C7SCL/SSI0XDAT0/T2CCP0/U3)
N18168142: R498.1 U66.1(DIR2) U66.10(DIR1)
N18192341: J5.B17 R595.2 R596.2
N18211886: R65.2 R66.2 U5.1(A)
N18211953: U5.4(Y) U131.2(A)
N18214699: J5.A11 R606.1
N18323233: R323.2 U41.21(B1)
N18323302: R353.1 U41.2(DIR)
N18887648: C384.2 MOD1.8(C1+)
N18887654: C384.1 MOD1.9(C1-)
N18887823: C385.2 MOD1.7(C2+)
N18887827: C385.1 MOD1.6(C2-)
N19207451: TP127.1(TP) U1.M21(SYSCLKOUT)
N19207912: C223.2 U1.C17(AUDOSC_IN) Y5.3(HOT2)
N19207996: C220.2 U1.A17(AUDOSC_OUT) Y5.1(HOT1)
N19208525: TP135.1(TP) U1.K1(OBSCLK_P)
N19208527: TP131.1(TP) U1.L1(OBSCLK_N)
N19208590: TP132.1(TP) U1.D24(RMII_REFCLK/PR0_ECAP0_ECAP_SYNC)
N19209091: R442.2 U1.D20(USB1_TXRTUNE_RKELVIN)
N19209222: R431.2 U1.C19(USB0_TXRTUNE_RKELVIN)
N19209666: C348.1 J30.2
N19250103: R523.2 SW13.1
N19351417: J34.33 R579.1
N19351424: J34.35 R578.1
N19354929: U106.4(Y) U140.2(A)
N19355586: J34.16 TP174.1(TP)
N19356463: J34.34 TP179.1(TP)
N19364584: TP138.1(TP) U1.Y20(RSV3)
N19364586: TP146.1(TP) U1.AB19(RSV2)
N19364588: TP144.1(TP) U1.AA19(RSV1)
N19364600: TP147.1(TP) U1.W19(RSV4)
N19367736: R482.2 U1.B9(PR0_PRU1_GPO17/PR0_PRU1_GPI17/P)
N19367738: R454.2 U1.A9(PR0_PRU1_GPO18/PR0_PRU1_GPI18/P)
N19367748: R451.2 U1.B10(PR0_PRU1_GPO19/PR0_PRU1_GPI19/P)
N19367766: R447.2 U1.A10(PR0_MDIO_DATA/GPIO1_04/MCASP0_A)
N19367768: R480.2 U1.C10(PR0_MDIO_MDCLK/GPIO1_05/MCASP0_)
N19367778: R476.2 U1.E10(PR1_PRU0_GPO0/PR1_PRU0_GPI0/GPI)
N19367788: R472.2 U1.D10(PR1_PRU0_GPO1/PR1_PRU0_GPI1/GPI)
N19367798: R469.2 U1.F10(PR1_PRU0_GPO2/PR1_PRU0_GPI2/GPI)
N19367816: R441.2 U1.C11(PR1_PRU0_GPO3/PR1_PRU0_GPI3/GPI)
N19367818: R437.2 U1.D11(PR1_PRU0_GPO4/PR1_PRU0_GPI4/MMC)
N19367846: R459.2 U1.E12(PR1_PRU0_GPO7/PR1_PRU0_GPI7/MMC)
N19367848: R481.2 U1.C12(PR1_PRU0_GPO8/PR1_PRU0_GPI8/MMC)
N19367866: R460.2 U1.B11(PR1_PRU0_GPO9/PR1_PRU0_GPI9/MMC)
N19367868: R477.2 U1.B12(PR1_PRU0_GPO10/PR1_PRU0_GPI10/M)
N19367970: R444.2 U1.C7(PR0_PRU1_GPO10/PR0_PRU1_GPI10/G)
N19368123: R468.2 U1.A8(PR0_PRU1_GPO12/PR0_PRU1_GPI12/G)
N19368147: R448.2 U1.C8(PR0_PRU1_GPO15/PR0_PRU1_GPI15/G)
N19368179: R470.2 U1.E9(PR0_PRU1_GPO11/PR0_PRU1_GPI11/G)
N19368226: R473.2 U1.B8(PR0_PRU1_GPO13/PR0_PRU1_GPI13/G)
N19368266: R458.2 U1.C9(PR0_PRU1_GPO16/PR0_PRU1_GPI16/G)
N19368284: R452.2 U1.D9(PR0_PRU1_GPO14/PR0_PRU1_GPI14/G)
N19368587: R439.2 U1.B5(PR0_PRU1_GPO0/PR0_PRU1_GPI0/GPI)
N19368605: R434.2 U1.B6(PR0_PRU1_GPO1/PR0_PRU1_GPI1/GPI)
N19368607: R430.2 U1.D7(PR0_PRU1_GPO2/PR0_PRU1_GPI2/GPI)
N19368625: R425.2 U1.A6(PR0_PRU1_GPO3/PR0_PRU1_GPI3/GPI)
N19368627: R422.2 U1.C6(PR0_PRU1_GPO4/PR0_PRU1_GPI4/GPI)
N19368645: R419.2 U1.E8(PR0_PRU1_GPO5/PR0_PRU1_GPI5/GPI)
N19368655: R416.2 U1.A7(PR0_PRU1_GPO6/PR0_PRU1_GPI6/GPI)
N19368657: R414.2 U1.D8(PR0_PRU1_GPO7/PR0_PRU1_GPI7/GPI)
N19368675: R412.2 U1.F9(PR0_PRU1_GPO8/PR0_PRU1_GPI8/GPI)
N19368677: R410.2 U1.B7(PR0_PRU1_GPO9/PR0_PRU1_GPI9/GPI)
N19368786: R405.2 U1.D6(PR0_PRU0_GPO16/PR0_PRU0_GPI16/G)
N19368850: R398.2 U1.B4(PR0_PRU0_GPO13/PR0_PRU0_GPI13/G)
N19368882: R402.2 U1.E7(PR0_PRU0_GPO15/PR0_PRU0_GPI15/G)
N19368922: R408.2 U1.C5(PR0_PRU0_GPO18/PR0_PRU0_GPI18/P)
N19368946: R394.2 U1.A4(PR0_PRU0_GPO14/PR0_PRU0_GPI14/G)
N19368978: R404.2 U1.C4(PR0_PRU0_GPO17/PR0_PRU0_GPI17/P)
N19369157: R423.2 U1.A2(PR0_PRU0_GPO1/PR0_PRU0_GPI1/GPI)
N19369167: R433.2 U1.E4(PR0_PRU0_GPO2/PR0_PRU0_GPI2/GPI)
N19369177: R415.2 U1.B1(PR0_PRU0_GPO3/PR0_PRU0_GPI3/GPI)
N19369187: R396.2 U1.A3(PR0_PRU0_GPO4/PR0_PRU0_GPI4/GPI)
N19369197: R420.2 U1.E5(PR0_PRU0_GPO5/PR0_PRU0_GPI5/GPI)
N19369349: R401.2 U1.B2(PR0_PRU0_GPO6/PR0_PRU0_GPI6/GPI)
N19369390: R413.2 U1.B3(PR0_PRU0_GPO12/PR0_PRU0_GPI12/G)
N19369435: R407.2 U1.E6(PR0_PRU0_GPO8/PR0_PRU0_GPI8/GPI)
N19369467: R417.2 U1.D5(PR0_PRU0_GPO11/PR0_PRU0_GPI11/G)
N19369503: R409.2 U1.D4(PR0_PRU0_GPO7/PR0_PRU0_GPI7/GPI)
N19369544: R411.2 U1.C3(PR0_PRU0_GPO10/PR0_PRU0_GPI10/G)
N19442104: R464.2 U1.H23(QSPI_CSN1/CLKOUT/GPIO1_65)
N19442180: R877.1 U72.16(SCK)
N19508261: P3.7 R580.1 U98.7(CANH) U104.1
N19508263: P3.2 R580.2 U98.6(CANL) U104.2
N19508331: R540.2 U98.2(RXD)
N19508333: C317.1 J25.1 R539.2 U98.3(TXD)
N19510567: P2.7 R581.1 U100.7(CANH) U105.1
N19510569: P2.2 R581.2 U100.6(CANL) U105.2
N19510637: R545.2 U100.2(RXD)
N19510639: C321.1 J26.1 R544.2 U100.3(TXD)
N19520807: R722.2 U52.H8(ZQ)
N19521112: TP128.1(TP) U52.A7(NF/TDQS#)
N19521127: RA16.7 U52.E8(NF/DQ5)
N19521129: RA16.6 U52.D2(NF/DQ6)
N19521147: RA16.8 U52.E3(NF/DQ4)
N19521183: RA16.5 U52.E7(NF/DQ7)
N19525941: C428.1 R216.2 R217.2
N19533446: R718.2 U49.H8(ZQ)
N19533734: TP126.1(TP) U49.A7(NF/TDQS#)
N19536013: R385.2 U1.W12(DDR3_RZQ0)
N19536015: R386.2 U1.V9(DDR3_RZQ1)
N19623002: J31.14 R586.2
N19626375: R251.1 U26.6(C)
N19628213: TP73.1(TP) U20.K1(PK2/AIN18/EPI0S2/U4RTS)
N19628231: TP72.1(TP) U20.K2(PK3/AIN19/EPI0S3/U4CTS)
N19631369: R155.2 R647.1 U18.7(VSENSE)
N19631412: C405.2 L3.1 U18.11(PH1) U18.12(PH2)
N19631425: C56.2 U18.9(SS/TR)
N19631427: C404.1 R140.1 U18.8(COMP)
N19631452: C405.1 U18.13(BOOT)
N19631454: C63.1 R140.2
N19631468: R157.2 U18.1(RT/CLK)
N19631560: J46.3 R131.2
N19636064: R702.2 R888.1 U32.N2(PWRDN)
N19636076: C472.2 TP109.1(TP) U32.G8(VREF)
N19636197: R668.2 U32.J5(BOOT1)
N19636243: R298.2 U32.F8(OSC32KIN)
N19636273: R284.2 U32.F7(OSC32KOUT)
N19636291: C127.2 R284.1 Y4.1
N19636350: C132.2 R298.1 Y4.2
N19636388: TP114.1(TP) U32.M6(EN2)
N19636390: TP116.1(TP) U32.M7(EN1)
N19636467: R325.2 U32.M5(SDA)
N19636469: R324.2 U32.M4(SCL)
N19643422: J18.2 R374.1
N19643490: J18.1 R370.1
N19723053: L4.1 U22.6(VSW#6) U22.7(VSW#7) U22.8(VSW#8)
N19738237: R266.1 R677.2 U31.15(1\O\E\)
N19748787: TP69.1(TP) U20.C2(PD0/AIN15/C0O/I2C7SCL/SSI2XDAT1)
N19748789: TP70.1(TP) U20.C1(PD1/AIN14/C1O/I2C7SDA/SSI2XDAT0)
N19748805: TP71.1(TP) U20.D2(PD2/AIN13/C2O/I2C8SCL/SSI2FSS/T)
N19748807: TP81.1(TP) U20.D1(PD3/AIN12/I2C8SDA/SSI2CLK/T1CCP)
N19748859: TP78.1(TP) U20.B4(PD5/AIN6/SSI1XDAT3/T3CCP1/U2TX)
N19748861: TP79.1(TP) U20.B3(PD6/AIN5/SSI2XDAT3/T4CCP0/U2RTS)
N19748877: TP80.1(TP) U20.B2(PD7/AIN4/NMT/SSI2XDAT2/T4CCP1/U)
N19749721: LD10.1 Q8.3(D)
N19749727: Q8.1(G) R39.1
N19749733: LD10.2 R589.2
N19749927: LD13.1 Q11.3(D)
N19749933: Q11.1(G) R42.1
N19749935: LD13.2 R588.2
N19752176: R226.1 U20.W15(RBIAS)
N19752383: R227.1 U21.1(TRI STATE)
N19760880: R403.1 U1.Y9(DDR3_VREFSSTL)
N19771684: R164.1 U20.A11(PN2/EPI0S29/U1DCD/U2RTS)
N19771691: R162.1 U20.B10(PN3/EPI0S30/U1DSR/U2CTS)
N19771705: R161.1 U20.B9(PN5/EPI0S35/I2C2SCL/U1RI/U3CTS)
N19771712: R163.1 U20.B11(PN1/U1CTS)
N19771719: R160.1 U20.C10(PN0/U1RTS)
N19771726: R221.1 U20.T12(PN6/EN0TXER/LCDDATA13/U4RTS)
N19776321: R450.1 U1.E24(SPI3_CLK/PR0_UART0_TXD/GPIO0_88)
N19776412: R220.1 U20.T6(PA2/I2C8SCL/SSI0CLK/T1CCP0/U4RX)
N19776797: J15.3 R219.1
N19776809: J15.1 R218.1
N19849959: R515.1 SW12.1
N19921815: R71.1 R607.2 U7.4(FB)
N19935028: R365.2 U1.W5(I2C0_SDA)
N19935032: R366.2 U1.U5(I2C0_SCL)
N19935171: R711.2 U1.W4(I2C1_SDA)
N19935173: R710.2 U1.V6(I2C1_SCL)
N19935221: R373.2 U1.M2(SPI0_CLK)
N19935328: R716.2 U1.R2(SPI2_CLK/GPIO0_103)
N19935623: R200.2 U20.N15(PG0/EN0PPS/EPI0S11/I2C1SCL/M0PW)
N19935654: R203.2 U20.T14(PG1/EPI0SI0/I2C1SDA/M0PWM5)
N19936542: TP181.1(TP) U20.M16(PG3/EN0TXEN/I2C2SDA/SSI2XDAT2)
N19936548: TP180.1(TP) U20.V11(PG2/EN0TXCK/I2C2SCL/SSI2XDAT3)
N19936677: R553.1 U95.7(SCLB)
N19998418: TP97.1(TP) U20.T19(XOSC1)
N20088320: TP56.1(TP) U20.A4(PD4/AIN7/SSI1XDAT2/T3CCP0/U2RX)
N20088340: R703.1 U32.L2(GPIO2)
N20088352: R340.1 U32.G3(GPIO6)
N20088355: R338.1 U32.L4(GPIO7)
N20088489: TP112.1(TP) U32.H4(NRESPWRON1)
N20088492: R245.1 U32.C7(NRESPWRON2)
N20088495: R341.1 U32.L3(INT1)
N20165134: R236.1 U23.6(C)
N20247908: R510.1 U82.L2(6Y1)
N20273568: R508.1 U82.M2(6Y3)
N20324932: R153.2 U20.A17(PB2/EN0MDC/EPI0S27/I2C0SCL/T5CC)
N20324951: R154.2 U20.B17(PB3/EN0MDIO/EPI0S28/I2C0SDA/T5C)
N20326127: TP86.1(TP) U20.U12(PN7/LCDDATA12/U1RTS/U4CTS)
N20326675: TP58.1(TP) U20.J1(PK0/AIN16/EPI0S0/U4RX)
N20326684: TP59.1(TP) U20.J2(PK1/AIN17/EPI0S1/U4TX)
N20327036: TP75.1(TP) U20.G2(PE3/AIN0/OWIRE/U1DTR)
N20327038: TP74.1(TP) U20.G1(PE2/AIN1/U1DCD)
N20327047: TP76.1(TP) U20.H2(PE1/AIN2/U1DSR)
N20327049: TP77.1(TP) U20.H3(PE0/AIN3/U1RTS)
N20327072: TP66.1(TP) U20.A7(PE6/AIN20/I2C9SCL/U0CTS)
N20327098: TP67.1(TP) U20.B7(PE7/AIN21/I2C9SDA/NMI/U0RTS)
N20333819: TP54.1(TP) U20.A10(PN4/EPI0S34/I2C2SDA/U1DTR/U3RTS)
N20333845: R195.1 U20.M4(PQ3/EPI0S23/SSI3XDAT1/T7CCP1)
N20334677: R166.1 U20.A16(PB0/CAN1RX/I2C5SCL/T4CCP0/U1RX/)
N20334698: R174.1 U20.B16(PB1/CAN1TX/I2C5SDA/T4CCP1/U1TX/)
N20368231: J5.B9 R604.1
N20368804: J5.A5 R598.1
N20391651: R507.1 U82.M1(6Y4)
N20474037: J16.1 R264.1
N20474249: J16.3 R252.1
N20476232: R312.2 U33.9(A7)
N20518193: R610.2 U7.5(EN)
N20519274: C14.2 U7.1(BOOT)
N21103341: R708.2 U1.V4(I2C2_SDA)
N21103343: R707.2 U1.V5(I2C2_SCL)
N21103450: R265.1 U38.5(SDA)
N21103457: R700.1 U38.6(SCL)
N21115682: J8.13 R240.2
N21115817: J8.14 R243.2
N21135598: TP160.1(TP) U62.14(Y0_P)
N21135600: TP161.1(TP) U62.15(Y0_N)
N21169756: TP20.1(TP) U20.V5(PA6/EN0RXCK/EPI0S8/I2C6SCL/SSI0)
N21170847: R302.2 U31.7(2A2)
N21170992: R282.1 R684.2 U31.2(1DIR)
N21171020: R291.1 R690.2 U31.3(2DIR)
N21171769: TP21.1(TP) U20.V7(PF4/EN0LED1/M0FAULT0/SSI3XDAT2/)
N21171778: TP22.1(TP) U20.W7(PF5/SSI3XDAT3)
N21184349: TP19.1(TP) U20.N1(PJ6/LCDAC/U4RTS)
N21185356: C283.2 R493.1 R495.2 Y8.1
N21185385: C295.2 R495.1 R496.1 Y8.3
N21231083: C268.2 U60.8(TRISTATE-EN)
N21235084: C51.1 J14.2
N21316200: R294.2 SW8.3(B1) SW8.4(B2)
N21319043: R222.2 U25.3(VSENSE)
N21320308: R223.1 R311.2 R793.2 U25.2(S\D\)
N21499820: TP13.1(TP) U20.V10(PT1/CAN0TX/EN0RXD1/LCDDATA11/T6)
N21500371: R5.2 U24.10(A8)
N21505605: R1.2 R494.1 U51.24(A2)
N21505608: R2.1 R497.2 U51.23(A1)
N21505611: R3.2 R4.1 U51.18(A0)
N21505922: LD1.2 R12.2
N21506103: LD3.2 R13.2
N21506291: LD5.2 R14.2
N21506486: LD4.2 R15.2
N21507867: LD2.2 R16.2
N21508122: TP191.1(TP) U51.1(P00)
N21508129: TP192.1(TP) U51.2(P01)
N21508178: TP9.1(TP) U51.8(P07)
N21508185: TP186.1(TP) U51.10(P10)
N21508192: TP187.1(TP) U51.11(P11)
N21508199: TP188.1(TP) U51.12(P12)
N21508206: TP189.1(TP) U51.13(P13)
N21508213: TP184.1(TP) U51.14(P14)
N21508220: TP185.1(TP) U51.15(P15)
N21690505: R784.1 R785.2 U112.4(ADD0)
N21783594: R788.2 U42.3(ALERT)
N21786150: R789.2 U43.3(ALERT)
N21786851: R792.2 U48.3(ALERT)
N21787536: R790.2 U44.3(ALERT)
N21787552: R791.2 U46.3(ALERT)
N21997071: R173.1 U17.F4(RTC_ALARM/U\A\R\T\2\_\C\T\S\/GP)
N21997073: R173.2 TP177.1(TP)
N22024660: TP178.1(TP) U17.K18(USB0_DRVVBUS)
N22048902: R19.1 U62.23(Y3_P)
N22048912: R20.1 U62.22(Y3_N)
N22048972: TP162.1(TP) U62.16(Y1_N)
N22048974: TP163.1(TP) U62.17(Y1_P)
N22366198: J5.B5 R800.1
N22366201: J5.B6 R801.1
N22367180: R803.2 U56.9(SCL/CCLK)
N22367188: R804.2 U56.10(SDA/CDIN)
N22388793: TP96.1(TP) U20.T7(PF3/EN0MDIO/M0PWM3/SSI3CLK/TRCL)
