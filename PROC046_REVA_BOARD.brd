# Allegro board PROC046_REVA_BOARD.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
DGND on L03_SIG1 (solid shape): 139.87,158.82 139.92,158.74 139.92,153.08 139.92,152.48 140.2,152.2 140.2,151.3 140.17,151.23 140.09,151.2 139.95,151.19 139.83,151.14 139.73,151.14 139.67,151.23 139.67,158.56 139.62,158.61 139.6,158.71 139.67,158.78 139.72,158.8 139.76,158.82
DGND on L03_SIG1 (solid shape): 221.21,105.48 221.23,105.37 221.14,105.31 221.07,105.31 218.79,103.03 218.68,103.01 218.62,103.1 218.62,104.24 219.51,105.14 220.07,105.14 220.69,105.21 220.66,105.83 220.64,105.85 220.64,105.92 220.78,105.92
DGND on L03_SIG1 (solid shape): 127.04,110.76 127.1,110.86 127.21,110.84 130.87,107.18 144.41,107.18 144.45,107.22 151.49,107.22 152.76,108.49 152.79,108.49 152.88,108.42 152.86,108.31 151.68,107.13 151.68,105.4 150.53,105.4 150.01,105.92 130.56,105.92 129.35,107.13 128.51,107.13 128.21,107.02 128.03,106.76 127.96,106.68 127.86,106.71 127.04,107.53
DGND on L03_SIG1 (solid shape): 188.38,119.53 188.43,119.49 188.48,119.45 188.55,119.42 188.63,119.4 189.48,118.54 189.68,118.54 189.68,118.49 189.67,118.42 189.27,118.03 189.24,118.04 189.05,118.06 188.87,118 188.82,117.96 188.77,117.92 186.87,117.92 185.9,118.89 185.89,118.97 185.88,119.02 185.73,119.25 185.47,119.36 185.45,119.36 185.37,119.44 185.35,119.5 185.4,119.53
DGND on L03_SIG1 (solid shape): 221.71,85.75 221.73,85.64 221.64,85.57 219.74,85.57 219.4,85.91 219.37,85.98 219.4,86.05 219.52,86.29 219.5,86.55 219.5,86.64 219.56,86.69 219.71,86.76 219.82,86.86 219.89,86.9 219.96,86.89 220.23,86.81 220.5,86.9 220.53,86.93
DGND on L03_SIG1 (solid shape): 81.27,187.02 81.37,186.96 81.35,186.85 80.71,186.21 80.71,184.91 79.68,184.91 79.6,184.96 79.58,185.05 79.58,185.33 79.4,185.56 79.36,185.64 79.39,185.72 79.55,186 79.49,186.31 79.49,186.41 79.58,186.46 79.65,186.46 80.21,187.02
DGND on L03_SIG1 (solid shape): 169.58,33.32 169.64,33.42 169.75,33.39 169.86,33.28 169.94,33.28 169.95,33.24 170.01,33.09 170.11,32.95 170.14,32.88 170.11,32.81 169.88,32.58 169.88,30.8 172.1,28.57 171.99,28.46 171.87,28.28 171.83,28.06 171.81,27.82 171.77,27.8 171.46,27.8 171.15,27.7 171.05,27.7 171.01,27.79 171.01,28.65 169.58,30.08
DGND on L03_SIG1 (solid shape): 210.45,87.32 210.51,87.42 210.63,87.4 210.64,87.38 212.9,87.38 212.91,87.33 212.92,87.27 212.94,87.21 212.93,87.12 212.84,87.07 212.75,87.07 212.61,87.05 212.49,86.97 212.37,86.85 212.25,86.97 212.13,87.05 211.99,87.07 211.73,87.07 211.59,87.05 211.47,86.97 211.35,86.85 211.23,86.97 211.11,87.05 210.97,87.07 210.57,87.07 210.54,87.05 210.48,87.04 210.45,87.08
DGND on L03_SIG1 (solid shape): 201.57,85.28 201.69,85.2 201.83,85.17 202.77,85.17 204.88,83.06 204.9,82.95 204.81,82.88 203.56,82.88 203.16,83.28 203.13,83.37 203.18,83.44 203.27,84.16 202.55,84.07 202.48,84.02 202.39,84.05 201.25,85.19 201.45,85.4
DGND on L03_SIG1 (solid shape): 79.91,58.87 79.96,58.86 80.02,58.79 80.02,50.73 80.23,50.52 80.23,50.45 80.02,50.24 80.02,47.25 79.96,47.16 79.85,47.18 79.64,47.39 79.61,47.47 79.66,47.54 79.81,48.13 79.24,48.35 79.15,48.36 79.11,48.44 79.11,51.7 79.84,52.44 79.84,58.8 79.88,58.85
DGND on L03_SIG1 (solid shape): 167.88,90.24 167.92,90.17 168.14,89.85 168.53,89.8 168.53,89.81 168.59,89.81 168.59,89.73 166.31,87.44 166.31,86.43 166.26,86.35 166.17,86.34 166.06,86.37 165.96,86.37 165.88,86.4 165.85,86.48 165.85,87.29 165.88,87.31 165.94,87.34 166,87.38 166.12,87.51 166.2,87.63 166.23,87.77 166.23,88.18 165.94,88.47 167.71,90.24 167.76,90.25 167.79,90.25
DGND on L03_SIG1 (solid shape): 222.52,83.91 222.52,83.54 222.47,83.45 222.37,83.44 221.85,83.31 221.87,82.77 221.89,82.7 221.86,82.64 221.78,82.52 221.73,82.39 221.73,82.38 221.68,82.33 221.63,82.38 221.63,82.4 221.59,82.52 221.51,82.63 221.47,82.67 221.55,82.74 221.55,83.61 220.98,84.18 220.95,84.29 221.05,84.36 222.07,84.36
DGND on L03_SIG1 (solid shape): 164.05,193.58 164.14,193.51 164.12,193.4 163.88,193.17 123.42,193.17 122.96,192.71 109.37,192.71 109.29,192.75 109.27,192.84 108.83,193.44 108.4,192.84 108.38,192.75 108.3,192.71 105.07,192.71 104.98,192.77 105,192.89 105.69,193.58
DGND on L03_SIG1 (solid shape): 180.33,181.51 180.38,181.42 180.38,178.06 182.19,176.25 182.22,176.14 182.12,176.08 179.63,176.08 178.63,177.08 178.63,180.63 178.66,180.71 178.74,180.73 179.05,180.8 179.24,181.05 179.29,181.1 179.68,181.17 179.92,181.48 179.99,181.5 180.12,181.49 180.24,181.52
DGND on L03_SIG1 (solid shape): 174.41,54.73 175.36,53.78 175.36,51.8 176.4,50.76 176.46,50.76 176.51,50.69 175.45,49.63 169.65,49.63 168.88,50.4 168.85,50.47 168.89,50.54 168.9,51.2 168.24,51.19 168.17,51.16 168.09,51.19 167.97,51.31 167.79,51.31 167.71,51.36 167.71,51.46 167.76,51.6 167.76,51.74 167.79,51.82 167.86,51.86 168.96,51.86 172.57,55.46 174.41,55.46
DGND on L03_SIG1 (solid shape): 185.14,92.1 185.33,92.1 185.33,91.8 185.68,91.45 186.08,91.45 186.23,91.48 186.34,91.56 186.47,91.69 186.55,91.81 186.58,91.95 186.58,92.1 187.17,92.1 187.25,92.03 187.21,91.98 187.02,91.67 187.13,91.32 187.15,91.21 187.06,91.15 184.01,91.15 183.93,91.07 183.82,91.05 183.76,91.14 183.76,92.31 183.8,92.39 183.89,92.41 183.94,92.39 183.99,92.39 184.17,92.39 184.31,92.42 184.43,92.5 184.59,92.66
DGND on L03_SIG1 (solid shape): 175.82,90.46 175.27,89.92 174.73,89.92 174.5,89.69 174.38,89.81 174.36,89.83 174.34,89.87 174.37,89.91 174.6,90.33 174.34,90.73 174.32,90.75 174.32,90.79 174.34,90.89 174.34,91.05 174.45,91.05 174.46,91.02 175.1,90.8 175.26,91.46 175.25,91.56 175.34,91.62 175.82,91.62
DGND on L03_SIG1 (solid shape): 54.33,182.2 54.45,182.22 54.51,182.12 54.51,181.07 54.47,180.99 54.38,180.97 53.8,180.53 54.38,180.09 54.47,180.08 54.51,180 54.51,179.43 54.88,179.06 54.88,178.36 54.63,178.12 54.63,177.79 54.6,177.74 54.53,177.69 54.44,177.72 53.12,179.05 51.43,179.05 51.34,179.11 51.36,179.22
DGND on L03_SIG1 (solid shape): 249.65,110.95 249.73,110.93 254.48,106.17 255.26,106.17 255.34,106.13 255.35,106.04 255.79,105.46 256.23,106.04 256.25,106.13 256.33,106.17 257.84,106.17 269.07,94.94 269.09,94.83 268.99,94.77 265.9,94.77 255.69,104.98 254.92,104.98 249.34,110.57 249.31,110.66 249.37,110.73 249.48,110.81 249.57,110.91
DGND on L03_SIG1 (solid shape): 62.87,175.94 63,175.91 63.13,175.92 63.73,175.92 66.45,173.2 66.47,173.09 66.38,173.03 63.7,173.03 62,174.73 61.98,174.83 62.06,174.9 62.3,175.02 62.43,175.27 62.43,175.28 62.48,175.33 62.53,175.28 62.53,175.27 63.36,175.1 62.87,175.79 62.81,175.79 62.81,175.95 62.87,175.95
DGND on L03_SIG1 (solid shape): 172.69,88.87 172.8,88.89 172.86,88.8 172.86,87.75 173.2,87.4 173.61,87.4 173.75,87.43 173.87,87.51 173.99,87.63 174.22,87.4 174.23,87.4 174.33,87.34 174.3,87.23 174.13,87.06 174.13,85.8 172.45,85.8 172.45,86.13 172.5,86.22 172.6,86.22 173.27,86.63 172.6,87.04 172.5,87.04 172.45,87.13 172.45,88.64
DGND on L03_SIG1 (solid shape): 170.95,90.42 171.05,90.39 171.18,90.26 171.18,89.8 171.68,89.31 171.84,89.31 171.93,89.25 171.91,89.14 171.72,88.94 171.72,81.45 171.68,81.37 171.59,81.35 171.31,81.35 171.09,81.19 171.01,81.15 170.92,81.19 170.76,81.32 170.56,81.37 170.53,81.39 170.51,81.42 170.51,81.46 170.5,81.56 170.59,81.56 170.93,81.9 170.93,87.04 170.33,87.63 170.33,89.88 170.36,89.95 170.43,89.98 170.72,90.08 170.88,90.34
DGND on L03_SIG1 (solid shape): 171.16,175.91 171.21,175.83 171.21,172.95 173.35,170.81 173.37,170.7 173.28,170.64 172.01,170.64 171.76,170.39 171.75,170.39 171.42,169.75 172.13,169.59 172.17,169.6 172.2,169.58 172.22,169.54 172.22,166.11 173.57,164.76 173.57,148.39 172.85,147.66 172.85,143.32 172.82,143.25 172.74,143.22 172.7,143.22 172.67,143.22 172.59,143.24 172.55,143.32 172.55,147.7 171.83,148.43 171.83,169.13 170.74,170.22 170.74,175.76 170.77,175.83 170.85,175.86 170.96,175.87 171.06,175.92
DGND on L03_SIG1 (solid shape): 86.22,186.48 86.24,186.39 86.18,186.31 85.99,185.62 86.71,185.6 86.73,185.62 86.8,185.62 86.8,185.49 87.67,184.62 87.68,184.56 87.63,184.53 87.6,184.53 87.24,184.17 87.14,184.14 87.07,184.23 86.74,184.6 86.26,184.46 86.19,184.42 86.11,184.45 85.71,184.85 85.71,185.33 83.54,187.51 83.51,187.62 83.61,187.68 85.01,187.68
DGND on L03_SIG1 (solid shape): 140.03,174.59 140.12,174.56 140.2,174.48 140.2,166.54 140.17,166.47 140.09,166.44 139.62,166.01 140.09,165.58 140.17,165.56 140.2,165.48 140.2,164.73 139.79,164.33 139.71,164.3 139.64,164.34 139.47,164.49 139.24,164.52 139.17,164.55 139.13,164.63 139.13,166.19 139.71,166.77 139.71,173.77 139.4,174.08 139.4,174.12 139.43,174.2 139.51,174.23 139.78,174.3 139.95,174.52
DGND on L03_SIG1 (solid shape): 290.81,43.61 290.89,43.58 291.2,43.27 291.2,39 291.59,38.62 291.59,36.27 291.37,36.05 291.26,36.03 291.2,36.12 291.2,36.92 290.32,37.8 290.3,37.8 287.98,40.11 287.96,40.22 288.05,40.29 288.44,40.29 289.37,41.22 289.39,41.22 289.63,41.99 288.86,41.76 288.85,41.74 288.14,41.02 286.9,41.02 286.82,41.07 286.81,41.16 286.84,41.25 286.84,41.35 286.84,41.71 287.32,42.19 287.48,42.19 287.86,42.57 287.89,42.57 288.73,43.42 290.38,43.42 290.58,43.46 290.74,43.58
DGND on L03_SIG1 (solid shape): 172.04,137 172.14,136.98 172.43,136.69 172.43,135.14 172.35,134.9 172.42,134.66 172.45,134.6 172.49,134.56 172.49,134.33 172.06,133.89 171.94,133.87 171.88,133.97 171.88,133.97 171.84,134.01 171.81,134.09 171.86,134.17 171.93,134.68 171.41,134.71 171.37,134.7 171.34,134.71 171.28,134.76 171.21,134.8 171.18,134.81 171.18,136.5 171.23,136.59 171.33,136.59 171.73,136.6 171.97,136.92
DGND on L03_SIG1 (solid shape): 295.47,33.85 295.47,31.61 294.98,31.13 294.97,31.12 294.77,30.96 294.68,30.71 294.61,30.62 294.51,30.64 291.43,33.72 291.43,33.82 291.49,33.91 291.6,33.89 292.54,32.95 294.04,32.95 294.14,33.05 294.16,33.05 294.52,33.59 293.98,33.95 293.91,33.96 293.87,34.02 293.32,34.34 292.98,33.8 292.96,33.72 292.88,33.68 292.85,33.68 292.02,34.51 292,34.62 292.09,34.68 294.63,34.68
DGND on L03_SIG1 (solid shape): 138.2,176.89 138.44,176.82 138.44,176.81 138.44,176.24 139.44,175.24 139.47,175.14 139.4,175.07 139.18,174.9 139.12,174.62 139.09,174.54 139.01,174.51 138.74,174.45 138.57,174.24 138.5,174.18 138.4,174.21 138.2,174.42 138.21,174.45 138.19,174.88 137.82,175.1 137.78,175.11 137.77,175.15 137.77,175.24 137.8,175.25 138.08,175.65 137.8,176.05 137.77,176.07 137.77,176.98 137.8,177.06 137.88,177.08 137.97,177.08 138.05,177.09
DGND on L03_SIG1 (solid shape): 182.24,95.73 182.08,95.57 181.25,96.4 180.29,96.4 179.98,96.7 179.97,96.71 179.31,96.63 179.42,95.98 179.46,95.92 179.45,95.85 179.47,95.41 179.86,95.19 179.93,95.16 179.96,95.09 180.06,94.83 180.29,94.67 180.32,94.65 180.32,94.61 180.31,94.57 179.87,94.12 179.76,94.1 179.69,94.19 179.69,94.32 179.35,94.66 177.69,94.66 177.59,94.72 177.61,94.83 178.23,95.44 178.52,95.44 179.02,95.95 179.02,96.8 178.68,97.14 178.66,97.25 178.76,97.31 180.66,97.31
DGND on L03_SIG1 (solid shape): 137.99,116.19 138.05,116.13 138.2,115.94 138.43,115.86 138.45,115.86 138.49,115.81 138.68,115.81 138.91,115.58 139.59,115.58 139.59,115.51 139.61,115.39 139.68,115.29 139.78,115.19 139.88,115.13 140,115.1 140.2,115.1 140.32,115.13 140.42,115.19 140.48,115.25 140.51,115.21 140.72,115.07 140.97,115.07 141.06,115.05 141.1,114.97 141.1,114.06 140.78,113.74 140.55,113.74 140.3,113.5 140.24,113.57 140.12,113.66 139.98,113.71 139.52,114.13 139.12,113.66 139.09,113.58 139.01,113.55 138.97,113.55 138.46,114.06 138.46,115.02 137.69,115.79 137.69,116.07 137.72,116.14 137.79,116.17 137.86,116.17 137.92,116.19
DGND on L03_SIG1 (solid shape): 118.6,54.18 118.62,54.09 118.65,54.03 118.65,53.93 118.56,53.88 117.83,53.88 117.6,53.65 115.84,53.65 115.75,53.71 115.77,53.82 115.98,54.03 116.72,54.03 117.45,54.4 116.72,54.76 115.67,54.76 115.14,54.23 114.74,54.23 114.65,54.28 114.65,54.38 114.25,55.06 113.85,54.38 113.85,54.28 113.76,54.23 111.81,54.23 111.81,55.11 111.78,55.14 111.77,55.19 111.82,55.22 117.55,55.22
DGND on L03_SIG1 (solid shape): 139.75,137.18 139.79,137.1 139.79,133.83 139.72,133.75 139.68,133.79 139.67,133.8 139,133.94 139.05,133.25 139.09,133.18 139.06,133.1 138.37,132.41 138.37,131.96 138.3,131.94 138.23,131.94 138.18,132 138.12,132.09 138.05,132.17 138.01,132.24 138.04,132.32 138.15,132.43 138.15,132.86 138.18,132.93 138.25,132.96 138.66,133.39 138.25,133.82 138.18,133.85 138.15,133.92 138.15,134.06 138.96,134.87 138.96,135.96 139.41,136.41 139.41,137.07 139.44,137.14 139.52,137.17 139.59,137.18 139.66,137.2
DGND on L03_SIG1 (solid shape): outline of 115 points within 281.17,97.78 283.65,103.97
DGND on L03_SIG1 (solid shape): 287.06,103.55 287.12,103.65 287.23,103.63 287.72,103.14 287.72,100.09 289.32,98.49 289.32,97.67 289.28,97.59 289.18,97.57 288.94,97.59 288.71,97.48 288.65,97.45 288.58,97.48 287.81,97.14 288.58,96.81 288.65,96.84 288.71,96.81 288.85,96.72 289.02,96.69 289.05,96.67 289.06,96.64 289.06,93.4 289.34,93.12 289.34,89.74 289.28,89.65 289.17,89.67 287.46,91.38 287.43,91.47 287.48,91.54 287.68,92.09 287.18,92.39 287.09,92.41 287.06,92.49
DGND on L03_SIG1 (solid shape): 198.22,145.63 198.3,145.6 198.33,145.52 198.61,145.05 199.14,145.2 199.22,145.24 199.31,145.2 199.84,145.05 200.12,145.52 200.15,145.6 200.23,145.63 200.73,145.63 200.81,145.59 200.83,145.5 201.27,144.92 201.71,145.5 201.73,145.59 201.81,145.63 202.47,145.63 202.92,145.19 202.92,140.28 202.95,140.26 202.97,140.15 202.88,140.08 202.44,140.08 197.73,144.8 197.73,144.9 197.74,144.92 197.81,145.2 197.71,145.47 197.7,145.57 197.79,145.63
DGND on L03_SIG1 (solid shape): outline of 145 points within 229.96,99.39 248.45,105.31
DGND on L03_SIG1 (solid shape): outline of 169 points within 190.88,139.65 201.68,145.63
DGND on L03_SIG1 (solid shape): 249.89,73.51 249.94,73.6 250.04,73.6 250.12,73.56 250.21,73.53 250.22,73.53 251.79,71.96 251.79,65.44 251.76,65.37 251.68,65.34 251.18,64.94 251.57,64.43 251.66,64.37 251.63,64.26 249.59,62.22 249.5,62.19 249.43,62.25 249.34,62.37 249.21,62.46 249.15,62.53 249.17,62.63 250.13,63.58 250.13,67.04 250.16,67.11 250.24,67.14 250.75,67.59 250.24,68.05 250.16,68.07 250.13,68.15 250.13,71.15 250.73,71.75 250.74,71.75 250.98,72.53 250.21,72.29 250.21,72.27 249.71,71.78 249.64,71.75 249.57,71.77 249.29,71.9 248.99,71.81 248.15,71.81 248.15,72.05 249.15,72.05 249.89,72.79
DGND on L03_SIG1 (solid shape): outline of 230 points within 173.41,108.07 182.57,111.45
DGND on L03_SIG1 (solid shape): 173.71,199.44 173.81,199.46 173.88,199.39 174.01,199.16 174.24,199.04 174.26,199.03 175.04,198.25 177.32,198.25 178.21,197.36 178.23,197.25 178.14,197.18 177.47,197.18 177.44,197.16 177.34,197.14 177.27,197.22 177.11,197.55 176.78,197.68 176.24,197.68 175.81,197.25 175.73,197.23 175.65,197.28 175.11,197.49 174.8,196.99 174.77,196.91 174.7,196.88 174.63,196.88 174.07,197.12 173.7,196.64 173.7,196.59 173.74,196.4 173.84,196.24 174.19,195.89 175.85,195.89 176.12,196.17 176.2,196.2 176.28,196.15 176.62,195.97 176.98,196.11 177.29,196.11 177.73,196.55 177.88,196.55 177.96,196.51 177.98,196.43 178.04,196.08 178.33,195.89 178.36,195.88 178.37,195.87 178.37,190.03 178.34,189.95 178.25,189.93 178.21,189.93 178.17,189.93 177.74,189.93 177.38,190.3 177.1,190.44 176.79,190.38 176.69,190.39 176.64,190.47 176.64,192.19 175.59,193.25 175.58,193.27 175.17,193.64 174.71,193.34 174.63,193.28 174.54,193.31 172.94,194.91 172.52,194.91 172.44,194.95 172.42,195.05 172.36,195.5 171.95,195.71 171.86,195.77 171.88,195.88 173.34,197.35 173.34,199.07
DGND on L03_SIG1 (solid shape): 189.69,102.08 189.73,102 189.73,101.69 188.1,100.07 188.1,98.61 188.28,98.42 188.31,98.34 188.26,98.26 188.17,97.55 188.89,97.64 188.96,97.69 189.05,97.66 189.79,96.91 189.81,96.8 189.72,96.74 188.56,96.74 187.73,97.57 187.73,99.69 187.26,100.15 185.18,100.15 184.68,99.65 184.67,99.65 184.54,99.61 184.43,99.53 184.37,99.5 184.3,99.52 183.57,99.14 184.34,98.83 184.4,98.86 184.47,98.84 184.77,98.74 185.06,98.86 185.14,98.89 185.22,98.84 185.47,98.62 185.85,98.63 185.88,98.61 185.92,98.55 185.92,97.88 186.95,96.85 186.97,96.74 186.88,96.67 185.31,96.67 184.55,97.43 184.55,97.72 184.38,97.9 184.38,97.92 184.05,98.35 183.54,98.16 183.46,98.11 183.38,98.14 181.03,100.49 178.49,100.49 178.34,100.64 178.32,100.75 178.41,100.81 183.89,100.81 185.08,102.01 187.57,102.01 187.66,101.97 187.67,101.87 188.09,101.25 188.52,101.87 188.53,101.97 188.61,102.01 189.44,102.01 189.52,102.1 189.61,102.1
DGND on L03_SIG1 (solid shape): outline of 261 points within 139.39,117.41 143.81,133.14
DGND on L03_SIG1 (solid shape): outline of 293 points within 174.13,191.52 190,211.14
DGND on L03_SIG1 (solid shape): outline of 94 points within 166.92,118.74 171.7,123.98
DGND on L03_SIG1 (solid shape): outline of 727 points within 94.45,183.28 125.84,191.72
DGND on L08_SIG2 (solid shape): 229.12,88.38 229.12,85.77 229.09,85.74 228.98,85.71 228.92,85.81 228.92,88.03 228.38,88.57 228.66,88.85
DGND on L08_SIG2 (solid shape): 105.27,94.29 105.3,94.34 105.36,94.33 108.52,91.16 108.74,91.16 112.07,87.83 112.09,87.72 112,87.66 111.82,87.66 105.27,94.21
DGND on L08_SIG2 (solid shape): 137.32,79.73 137.41,79.67 137.39,79.56 136.82,79 133.4,79 133.21,79.19 133.16,79.19 133.11,79.22 133.12,79.27 133.58,79.73
DGND on L08_SIG2 (solid shape): 138.24,106.17 138.27,106.06 138.17,106 131.83,106 131.56,106.27 131.54,106.38 131.63,106.44 137.97,106.44
DGND on L08_SIG2 (solid shape): 139.63,82.73 139.73,82.67 139.7,82.56 138.46,81.31 133.49,81.31 133.4,81.37 133.42,81.48 134.67,82.73
DGND on L08_SIG2 (solid shape): 141.03,77.8 141.12,77.74 141.1,77.63 140.83,77.36 138.21,77.36 138.11,77.42 138.13,77.53 138.4,77.8
DGND on L08_SIG2 (solid shape): 146.99,97.34 147.01,97.23 146.92,97.16 142.66,97.16 142.25,97.57 142.23,97.68 142.32,97.74 146.58,97.74
DGND on L08_SIG2 (solid shape): 147.39,103.44 147.41,103.33 147.32,103.27 141.53,103.27 140.55,104.25 140.52,104.36 140.62,104.42 146.41,104.42
DGND on L08_SIG2 (solid shape): 154.84,106.3 154.94,106.24 154.92,106.13 154.84,106.04 150.65,106.04 150.62,106.07 150.61,106.13 150.66,106.16 153.37,106.16 153.51,106.3
DGND on L08_SIG2 (solid shape): 219.76,100.72 219.82,100.82 219.93,100.79 220.38,100.34 220.38,98.33 220.32,98.24 220.21,98.26 219.76,98.71
DGND on L08_SIG2 (solid shape): 227.37,102.85 227.48,102.87 227.54,102.78 227.54,101.06 225.08,98.6 224.97,98.58 224.9,98.67 224.9,100.38
DGND on L08_SIG2 (solid shape): 264.25,28.02 264.36,28.05 264.43,27.95 264.43,27.73 261.52,24.83 261.31,24.83 261.21,24.89 261.23,25
DGND on L08_SIG2 (solid shape): 283.36,51.47 283.39,51.51 283.45,51.5 283.54,51.41 283.54,49.71 281.52,47.69 281.41,47.66 281.34,47.76 281.34,48.53 283.36,50.55
DGND on L08_SIG2 (solid shape): 200.56,27.7 200.64,27.73 200.71,27.7 204.23,24.18 209.96,24.18 210.06,24.12 210.04,24.01 209.98,23.95 204.23,23.95 200.52,27.66
DGND on L08_SIG2 (solid shape): 244.85,71.41 244.97,71.33 245.11,71.3 245.28,71.3 245.28,70.98 245.43,70.82 245.46,70.71 245.36,70.65 244.68,70.65 244.68,70.85 244.26,71.27 244.62,71.64
DGND on L08_SIG2 (solid shape): 154.45,24.98 154.55,24.92 154.53,24.81 153.87,24.16 132.78,24.16 132.44,24.49 132.42,24.6 132.51,24.67 153.8,24.67 154.11,24.98
DGND on L08_SIG2 (solid shape): 179.99,60.51 180.08,60.44 180.06,60.33 179.26,59.53 179.26,55.38 179.2,55.29 179.09,55.31 178.73,55.67 178.73,59.76 179.47,60.51
DGND on L08_SIG2 (solid shape): 161.6,100.13 161.64,100.1 161.63,100.04 161.58,99.99 160.96,99.99 159.63,98.65 159.63,98.52 159.6,98.45 159.53,98.42 159.4,98.39 159.28,98.33 155.98,98.33 155.27,99.04 156.36,100.13
DGND on L08_SIG2 (solid shape): 225.41,83.97 225.48,84.06 225.59,84.04 225.74,83.89 225.74,80.85 225.59,80.69 225.48,80.67 225.41,80.76 225.41,81.95 225.09,82.27 225.09,82.5 225.41,82.82
DGND on L08_SIG2 (solid shape): 231.76,40.9 231.83,40.99 231.94,40.97 232.04,40.86 232.06,40.86 233.69,39.23 233.69,38.87 233.63,38.77 233.52,38.8 232.78,39.54 232.78,39.79 231.76,40.81
DGND on L08_SIG2 (solid shape): 236.26,34.7 236.26,34.22 236.2,34.13 236.09,34.15 234.92,35.31 234.72,35.31 234.68,35.35 234.68,35.55 234.56,35.67 234.54,35.78 234.64,35.84 235.11,35.84
DGND on L08_SIG2 (solid shape): 297.35,96.88 297.46,96.9 297.52,96.81 297.52,72.18 294.78,69.43 294.78,56.66 294.72,56.57 294.61,56.59 294.08,57.12 294.08,62.8 293.27,63.62 293.27,92.8
DGND on L08_SIG2 (solid shape): 188.17,123.24 188.27,123.18 188.24,123.07 187.76,122.58 185.23,122.58 185.14,122.64 185.15,122.74 185.19,122.82 185.22,122.9 185.22,122.92 185.55,123.24
DGND on L08_SIG2 (solid shape): 292.86,62.56 292.92,62.65 293.03,62.63 293.22,62.45 293.22,56.76 294.23,55.74 294.23,55.34 293.42,54.52 293.42,53.74 291.03,51.35 290.93,51.35 290.83,51.41 290.86,51.52 292.86,53.52
DGND on L08_SIG2 (solid shape): 193.81,93.21 193.85,93.25 193.9,93.24 194.41,92.74 195.04,92.74 195.14,92.64 195.14,91.91 195.1,91.87 195.05,91.88 195.03,91.89 194.93,91.96 194.81,91.98 194.59,91.98 194.59,92.34 193.81,93.11
DGND on L08_SIG2 (solid shape): 144.58,62.69 144.63,62.7 144.67,62.65 144.67,62.54 134.88,52.76 134.77,52.73 134.71,52.83 134.71,52.92 134.75,52.96 134.75,53.05 134.8,53.1 135,53.1
DGND on L08_SIG2 (solid shape): 147.76,57.3 147.85,57.24 147.83,57.13 142.94,52.24 142.94,52.23 142.37,51.67 142.34,51.7 142.26,51.76 142.18,51.81 142.11,51.88 142.14,51.97 147.47,57.3
DGND on L08_SIG2 (solid shape): 87.67,60.22 87.76,60.2 88.56,59.4 88.56,36.29 88.49,36.2 88.38,36.22 87.11,37.49 87.11,59.76 87.24,59.89 87.26,59.89 87.46,59.98 87.59,60.16
DGND on L08_SIG2 (solid shape): 248.87,60.2 248.96,60.15 248.96,60.05 248.92,59.89 248.95,59.73 248.96,59.72 248.96,59.43 248.26,58.73 247.8,58.73 247.7,58.79 247.73,58.9 247.74,58.91 247.74,59.5 248.44,60.2
DGND on L08_SIG2 (solid shape): 216.6,91.65 216.71,91.63 218.64,89.69 219.99,89.69 220.4,90.1 221.13,90.1 221.54,89.69 222.48,89.69 222.71,89.46 222.42,89.17 222.32,89.17 222.31,89.16 222.19,89.16 222.18,89.17 219.02,89.17 219.01,89.16 218.89,89.16 218.88,89.17 218.77,89.17 218.49,89.45 218.49,89.46 216.5,91.45 216.53,91.52 216.54,91.57
DGND on L08_SIG2 (solid shape): 288.33,54.32 288.44,54.34 288.51,54.25 288.51,53.75 284.7,49.95 284.59,49.92 284.53,50.02 284.53,53.57 284.5,53.6 284.49,53.65 284.54,53.69 284.9,53.69 285.39,53.19 287.2,53.19
DGND on L08_SIG2 (solid shape): 256.66,48.34 256.93,48.25 257.2,48.34 257.73,48.34 257.97,48.11 257.99,47.99 257.89,47.93 254.45,47.93 254.21,48.17 254.19,48.28 254.29,48.34
DGND on L08_SIG2 (solid shape): 154.82,101.89 154.91,101.84 154.9,101.73 154.82,101.41 154.97,101.12 155,101.01 154.9,100.94 150.07,100.94 149.79,101.22 149,101.22 148.45,101.77 148.58,101.89
DGND on L08_SIG2 (solid shape): 218.88,107.08 218.94,106.99 218.94,102.76 218.77,102.6 218.77,98.55 218.71,98.46 218.6,98.48 218.3,98.77 218.3,106.88 218.34,106.96 218.42,106.98 218.6,106.99 218.77,107.07
DGND on L08_SIG2 (solid shape): 117.6,91.4 133.33,91.4 133.38,91.45 133.58,91.45 133.65,91.42 133.68,91.35 133.7,91.21 133.75,91.08 133.76,90.97 133.67,90.92 115.48,90.92 113.32,93.08 113.29,93.2 113.39,93.26 115.75,93.26
DGND on L08_SIG2 (solid shape): 131.67,92.59 131.69,92.48 131.6,92.42 117.97,92.42 117.92,92.47 117.97,92.52 117.99,92.52 118.36,92.73 118.41,93.15 118.42,93.24 118.5,93.29 130.97,93.29
DGND on L08_SIG2 (solid shape): 150.32,128.62 150.38,128.71 150.49,128.69 151.43,127.75 152.03,127.75 152.19,127.77 152.34,127.84 152.48,127.77 152.64,127.75 153.16,127.75 153.3,127.61 153.3,127.22 153.24,127.13 153.13,127.15 153.06,127.22 150.6,127.22 150.32,127.5
DGND on L08_SIG2 (solid shape): 168.55,146.4 168.59,146.31 168.59,144.58 168.69,144.48 168.69,141.73 168.41,141.46 168.41,138.02 168.38,137.95 168.31,137.92 168.29,137.92 168.22,137.95 168.19,138.02 168.19,139.32 167.87,139.64 167.87,143.65 168.19,143.97 168.19,146.27 168.22,146.34 168.29,146.37 168.37,146.38 168.45,146.41
DGND on L08_SIG2 (solid shape): 191.06,73.18 191.12,73.12 191.12,72.16 190.33,71.36 190.32,71.36 189.73,70.77 189.73,70.76 189.61,70.64 189.6,70.64 189.01,70.05 189.01,70.04 188.89,69.92 188.88,69.92 188.29,69.33 188.29,69.32 188.17,69.2 188.16,69.2 187.57,68.62 187.57,68.61 187.45,68.49 187.44,68.49 186.85,67.9 186.85,67.89 186.73,67.77 186.72,67.77 186.14,67.18 186.14,67.17 186.02,67.05 186.01,67.05 185.42,66.46 185.42,66.45 184.55,65.59 184.48,65.59 184.38,65.65 184.4,65.76 190.65,72.01 190.65,74.29 191.06,74.29
DGND on L08_SIG2 (solid shape): 235.24,51.34 234.96,51.06 232.97,51.06 232.6,51.42 232.6,52.27 232.64,52.35 232.72,52.37 233.15,52.72 232.72,53.07 232.64,53.09 232.6,53.17 232.6,53.27 235.24,53.27
DGND on L08_SIG2 (solid shape): 285.9,36.44 285.9,36.43 286.28,36.06 286.75,36.29 286.82,36.34 286.91,36.31 288.68,34.53 288.68,34.11 288.62,34.02 288.51,34.04 287.48,35.07 285.62,35.07 285.62,36.55 285.32,36.85 285.31,36.9 285.36,36.93 285.4,36.93
DGND on L08_SIG2 (solid shape): 120.98,125.05 121.05,125.02 121.08,124.94 121.18,124.64 121.45,124.47 121.47,124.47 121.7,124.24 121.81,124.24 121.81,124.16 121.8,124.15 121.69,123.97 121.67,123.77 121.65,123.69 121.57,123.65 119.84,123.65 118.84,124.65 118.81,124.76 118.91,124.82 118.98,124.82 119.2,125.05
DGND on L08_SIG2 (solid shape): 184.37,92.34 184.43,92.43 184.54,92.41 184.86,92.09 184.86,79.45 185.52,78.79 185.54,78.68 185.44,78.62 183.69,78.62 183.69,82.08 184.28,82.08 184.59,82.39 184.59,82.78 184.57,82.9 184.5,83 184.35,83.16 184.5,83.31 184.57,83.42 184.59,83.54 184.59,83.79 184.57,83.91 184.5,84.02 184.37,84.14 184.27,84.21 184.15,84.24 183.69,84.24 183.69,87.86 184.37,88.53
DGND on L08_SIG2 (solid shape): 158.52,107.28 158.5,107.26 157.61,105.52 158.5,103.79 158.52,103.77 158.52,103.7 158.38,103.7 157.12,104.96 152.81,104.96 152.73,104.99 152.7,105.06 152.7,105.13 152.7,105.19 152.72,105.27 152.8,105.31 155.14,105.31 155.41,105.58 156.53,105.58 158.3,107.35 158.52,107.35
DGND on L08_SIG2 (solid shape): 181.27,85.69 181.27,85.11 180.6,84.44 180.49,84.42 180.43,84.51 180.43,84.81 180.46,84.88 180.54,84.91 181,85.47 180.34,85.77 180.31,85.76 177.36,88.7 177.34,88.81 177.44,88.88 178.08,88.88
DGND on L08_SIG2 (solid shape): 261.16,49.12 261.16,49.1 261.62,48.66 262.08,49.1 262.08,49.12 262.25,49.29 262.36,49.31 262.42,49.22 262.42,49.04 261.4,48.02 261.38,48.01 261.11,47.85 261.01,47.55 260.98,47.48 260.91,47.45 260.53,47.45 258.03,49.95 258.03,50.24 260.04,50.24
DGND on L08_SIG2 (solid shape): 258.88,38.26 258.89,38.27 258.92,38.28 258.95,38.29 258.98,38.29 259.01,38.27 259.03,38.26 259.05,38.23 259.05,38.2 259.05,38.19 259.05,34.56 253.39,28.89 249.98,28.89 249.96,28.9 249.93,28.9 249.91,28.92 249.89,28.94 249.88,28.97 249.87,29 249.88,29.03 249.89,29.06 249.9,29.07 250.84,30 252.02,30 253.01,30.99 253.56,30.99 253.56,30.93 253.57,30.87 253.59,30.81 253.62,30.75 253.66,30.7 253.7,30.66 253.74,30.62 253.8,30.59 253.85,30.56 253.91,30.54 253.97,30.53 254.03,30.53 254.09,30.54 254.15,30.55 254.21,30.57 254.26,30.6 254.31,30.64 254.35,30.68 254.39,30.73 254.42,30.78 254.45,30.84 254.46,30.9 254.47,30.96 254.47,31.02 254.46,31.08 254.45,31.14 254.42,31.19 254.39,31.25 254.35,31.3 254.31,31.34 254.26,31.37 254.21,31.4 254.15,31.43 254.09,31.44 254.03,31.45 253.97,31.44 253.91,31.43 253.85,31.42 253.8,31.39 253.74,31.36 253.7,31.32 253.66,31.27 253.62,31.22 253.59,31.17 253.57,31.11 253.56,31.05 253.56,30.99 253.01,30.99 256.15,34.13 256.15,35.52
DGND on L08_SIG2 (solid shape): 234.23,77.03 234.23,76.76 233.22,76.76 232.99,76.52 232.91,76.4 232.88,76.26 232.88,75.86 233.22,75.51 234.23,75.51 234.23,74.96 234.02,74.96 233.88,74.93 233.76,74.85 233.63,74.72 233.55,74.61 233.52,74.46 233.52,74.21 233.55,74.07 233.63,73.95 233.69,73.89 233.64,73.85 233.63,73.84 233.53,73.81 233.44,73.74 233.32,73.62 233.28,73.58 233.26,73.53 233.18,73.48 233.1,73.51 231.27,75.33 231.24,75.41 231.29,75.49 231.48,75.75 231.45,76.07 231.44,76.11 232.42,77.09 234.16,77.09
DGND on L08_SIG2 (solid shape): 201.92,98.66 201.95,98.71 202,98.7 202.11,98.59 203.88,98.59 205.61,96.86 205.61,96.51 205.56,96.43 205.47,96.42 205.07,96.43 204.81,96.12 204.74,96.05 204.64,96.07 204.37,96.35 204.2,96.35 204.15,96.39 204.15,97.16 203.92,97.39 203.92,97.41 203.67,98.12 203.1,97.63 203.04,97.53 202.93,97.55 201.92,98.56
DGND on L08_SIG2 (solid shape): 219.6,86.4 219.7,86.37 219.81,86.26 222.05,86.26 224.43,83.87 224.43,83.33 224.12,83.01 224.12,81.87 224.43,81.55 224.43,80.44 221.26,77.27 221.19,77.24 221.12,77.27 220.87,77.38 220.6,77.32 219.74,77.32 219.27,77.79 219.27,80.48 219.01,80.74 219.01,81.76 219.05,81.83 219.13,81.86 219.19,81.85 219.26,81.82 219.29,81.75 219.29,80.71 219.81,80.19 222.45,80.19 223.28,81.02 223.28,82.72 222.58,83.42 222.43,83.42 222.41,83.42 222.27,83.47 222.13,83.47 222.04,83.5 222.01,83.57 222.01,84.06 220.24,85.83 219.38,85.83 219.35,85.86 219.32,85.94 219.36,86.01 219.47,86.15 219.53,86.31
DGND on L08_SIG2 (solid shape): 144.55,121.1 145.27,121.1 145.45,121.28 145.94,120.78 145.96,120.75 145.94,120.71 145.83,120.54 145.8,120.33 145.8,120.28 145.24,120.28 145.02,120.23 144.84,120.11 144.74,120.01 144.69,119.96 144.65,119.9 144.57,119.84 144.49,119.88 144.45,119.92 144.29,120.08 144.31,120.11 144.12,120.71 143.53,120.49 143.52,120.46 143.43,120.46 143.43,120.51 143.39,120.73 143.27,120.91 143.19,120.98 143.01,121.11 142.8,121.15 142.6,121.15 142.54,121.14 142.49,121.14 142.4,121.16 142.37,121.24 142.37,121.88 142.47,121.99 143.66,121.99
DGND on L08_SIG2 (solid shape): 165.22,44.35 165.33,44.37 165.39,44.28 165.39,43.55 155.82,33.98 142.17,33.98 140.28,32.1 140.28,31.08 139.98,30.78 139.91,30.77 139.83,30.76 138.62,30.32 138.66,29.03 138.67,28.93 138.58,28.87 137.54,28.87 137.45,28.93 137.46,29.03 137.5,30.33 136.28,30.75 136.21,30.76 136.15,30.77 135.92,31 135.92,32.19 138.1,34.38 155.25,34.38
DGND on L08_SIG2 (solid shape): 127.45,24.97 127.54,24.92 127.54,24.82 127.94,24.14 128.34,24.82 128.34,24.92 128.43,24.97 130.92,24.97 131.82,24.08 131.84,23.97 131.74,23.9 130.46,23.9 130.37,23.96 130.38,24.07 130.02,24.81 129.66,24.07 129.67,23.96 129.58,23.9 126.91,23.9 126.02,24.8 126,24.91 126.09,24.97
DGND on L08_SIG2 (solid shape): outline of 141 points within 59.02,121.21 103.11,168.07
DGND on L08_SIG2 (solid shape): outline of 143 points within 156.48,32.9 170.09,47.98
DGND on L08_SIG2 (solid shape): 178.25,66.14 178.35,66.14 178.74,65.76 178.76,65.65 178.67,65.59 177.24,65.59 176.9,65.25 176.81,65.22 176.74,65.28 176.15,65.5 175.89,64.93 175.88,64.84 175.8,64.8 175.33,64.8 175.25,64.84 175.24,64.93 174.8,65.54 174.37,64.93 174.36,64.84 174.27,64.8 173.81,64.8 173.73,64.84 173.71,64.93 173.28,65.54 172.85,64.93 172.83,64.84 172.75,64.8 172.33,64.8 171.31,63.77 171.2,63.75 171.13,63.84 171.13,65.34 171.96,66.17 178.22,66.17
DGND on L08_SIG2 (solid shape): 113.53,184.01 113.56,184.06 113.61,184.05 113.68,183.99 113.68,178.78 116.8,175.65 116.8,132.4 110.54,126.14 110.43,126.11 110.36,126.21 110.36,132.41 110.18,132.6 110.24,132.66 110.27,132.65 114.09,138.1 108.39,134.66 108.35,134.54 108.22,134.56 107.68,135.09 107.68,144.08 113.53,149.92 113.53,166.73 114.06,167.63 113.53,168.53
DGND on L08_SIG2 (solid shape): outline of 198 points within 193.15,121.09 224.46,141.8
DGND on L08_SIG2 (solid shape): 152.22,63.71 152.26,63.53 152.37,63.38 152.4,63.31 152.37,63.23 152.33,63.19 152.25,63.16 151.85,63.34 151.45,63.16 151.38,63.19 150.75,63.21 150.77,62.58 150.8,62.51 150.77,62.43 150.64,61.97 151.02,61.68 151.04,61.67 151.23,61.48 151.31,61.48 151.49,61.26 151.76,61.12 151.95,61.1 152.14,61.12 152.17,61.13 152.26,61.03 152.29,60.96 152.27,60.89 152.27,60.29 152.88,60.28 152.95,60.31 153.02,60.28 153.57,59.73 153.6,59.62 153.5,59.55 148.19,59.55 148.09,59.62 148.12,59.73 148.15,59.76 148.23,59.88 148.26,60.02 148.26,60.19 148.58,60.19 148.87,60.48 148.95,60.6 148.98,60.74 148.98,60.91 149.3,60.91 149.59,61.2 149.67,61.32 149.7,61.46 149.7,61.63 150.02,61.63 150.31,61.92 150.39,62.04 150.41,62.18 150.41,62.51 149.34,63.58 149.32,63.69 149.41,63.76 152.22,63.76
DGND on L08_SIG2 (solid shape): outline of 215 points within 182.69,23.85 198.33,27.97
DGND on L08_SIG2 (solid shape): outline of 224 points within 265.24,52.02 270.79,70.71
DGND on L08_SIG2 (solid shape): outline of 247 points within 111.32,98.73 142.73,184.38
DGND on L08_SIG2 (solid shape): outline of 329 points within 202.81,67.83 210.57,95.68
DGND on L08_SIG2 (solid shape): 113.6,91.66 113.66,91.75 113.77,91.73 115.22,90.29 132.17,90.29 132.25,90.25 132.27,90.16 132.72,89.6 133.16,90.16 133.18,90.25 133.26,90.29 137.17,90.29 137.26,90.24 137.26,90.14 137.23,89.81 137.42,89.55 137.46,89.48 137.45,89.41 137.39,89.3 137.37,89.19 137.36,89.14 135.53,89.05 135.26,89.33 130.72,89.33 130.64,89.37 130.62,89.46 130.17,90.01 129.73,89.46 129.71,89.37 129.63,89.33 129.45,89.33 129.37,89.37 129.35,89.46 128.91,90.01 128.46,89.46 128.44,89.37 128.36,89.33 128.18,89.33 128.1,89.37 128.08,89.46 127.64,90.01 127.19,89.46 127.17,89.37 127.09,89.33 126.91,89.33 126.83,89.37 126.81,89.46 126.37,90.01 125.92,89.46 125.9,89.37 125.82,89.33 125.64,89.33 125.56,89.37 125.54,89.46 125.09,90.01 124.65,89.46 124.63,89.37 124.55,89.33 124.37,89.33 124.29,89.37 124.27,89.46 123.83,90.01 123.38,89.46 123.36,89.37 123.28,89.33 115.76,89.33 113.6,91.49
DGND on L08_SIG2 (solid shape): outline of 419 points within 281.24,39.63 295.16,54.52
DGND on L08_SIG2 (solid shape): outline of 484 points within 146.6,89.37 163.67,98.6
DGND on L08_SIG2 (solid shape): outline of 489 points within 176.23,114.52 181.14,119.63
DGND on L08_SIG2 (solid shape): outline of 640 points within 244.53,49.08 257.72,54.93
DGND on TOP: 241.94,184.6 241.94,182.84 242.19,182.59 243.38,182.59 243.38,183.78 243.51,183.91 243.51,184.93 243.31,185.13 242.47,185.13
DGND on TOP: 6.76,70.3 6.76,68.44 4.98,68.44 4.98,70.3
DGND on TOP: 285.75,34.94 285.75,36.21 287.4,36.21 287.4,34.94
DGND on TOP: 205.64,216.45 205.64,219.52 202.77,219.52 202.77,216.45
DGND on TOP: 170.81,146.45 171.07,146.19 174.5,146.19 174.62,146.32 174.62,150.38 174.24,150.76 170.94,150.76 170.81,150.64
DGND on L02_GND1: 1.91,8.27 1.91,249.85 191.9,249.85 192.38,250.33 194.21,250.33 194.69,249.85 262.74,249.85 262.75,249.57 262.6,249.33 262.57,249.25 262.6,249.18 262.75,248.69 262.4,248.32 262.36,248.28 262.39,248.23 262.45,248.19 262.76,248.3 263.08,248.19 263.13,248.22 263.18,248.25 263.23,248.33 263.2,248.42 263.02,248.79 263.18,249.18 263.21,249.25 263.18,249.33 263.03,249.57 263.04,249.85 304.16,249.85 304.16,8.27 180.97,8.27 180.97,22.37 159.64,22.37 159.64,8.27 ; 11 cut-outs
DGND on L04_GND2: 1.91,8.27 1.91,249.85 262.74,249.85 262.75,249.57 262.6,249.33 262.57,249.25 262.6,249.18 262.75,248.69 262.4,248.32 262.36,248.28 262.39,248.23 262.45,248.19 262.76,248.3 263.08,248.19 263.13,248.22 263.18,248.25 263.23,248.33 263.2,248.42 263.02,248.79 263.18,249.18 263.21,249.25 263.18,249.33 263.03,249.57 263.04,249.85 304.16,249.85 304.16,8.27 180.97,8.27 180.97,22.37 159.64,22.37 159.64,8.27 ; 11 cut-outs
DGND on L07_GND3: 1.91,8.27 1.91,249.87 262.73,249.87 262.75,249.58 262.6,249.33 262.57,249.25 262.6,249.18 262.75,248.69 262.4,248.32 262.36,248.28 262.39,248.23 262.45,248.19 262.76,248.3 263.08,248.19 263.13,248.22 263.18,248.25 263.23,248.33 263.2,248.42 263.02,248.79 263.18,249.18 263.21,249.25 263.18,249.33 263.03,249.58 263.05,249.87 304.16,249.87 304.16,8.27 180.97,8.27 180.97,22.37 159.64,22.37 159.64,8.27 ; 11 cut-outs
DGND on L09_GND4: 1.91,8.27 1.91,249.85 262.74,249.85 262.75,249.57 262.6,249.33 262.57,249.25 262.6,249.18 262.75,248.69 262.4,248.32 262.36,248.28 262.39,248.23 262.45,248.19 262.76,248.3 263.08,248.19 263.13,248.22 263.18,248.25 263.23,248.33 263.2,248.42 263.02,248.79 263.18,249.18 263.21,249.25 263.18,249.33 263.03,249.57 263.04,249.85 304.16,249.85 304.16,8.27 180.97,8.27 180.97,22.37 159.64,22.37 159.64,8.27 ; 10 cut-outs
DVDD33 on TOP: 276.86,151.93 276.86,149.16 277.42,148.6 277.42,144.72 274.07,141.37 274.07,126.35 274.83,125.59 284.96,125.59 285.5,126.13 285.5,149.04 282.57,151.96 280.11,151.96 280.09,151.93
DVDD33 on L05_PWR1: 273.69,151.78 274.32,152.41 284.48,152.41 285.75,151.14 285.75,127.01 283.84,125.11 273.69,125.11 272.41,126.38 272.41,132.98 274.57,135.14 274.57,143.02 273.69,143.91
DVDD33 on L06_PWR2: 267.97,165.75 267.97,148.6 270.51,146.06 271.14,146.06 272.41,144.79 272.41,139.08 273.05,138.44 281.94,138.44 283.84,140.35 283.84,150.51 282.57,151.78 274.95,151.78 273.69,153.05 273.69,160.03 276.86,163.21 276.86,164.48 274.95,166.38 268.61,166.38
DVDD33 on L06_PWR2: 165.48,129.3 167.89,129.3 168.27,128.92 168.27,125.11 168.53,124.86 169.54,124.86 170.69,123.71 170.69,119.65 171.07,119.27 173.23,119.27 173.61,118.89 173.61,114.44 173.23,114.06 168.66,114.06 167.64,113.04 167.64,112.66 167.26,112.28 166.62,112.28 166.12,111.77 166.12,107.96 165.35,107.2 165.35,102.76 165.42,102.69 165.42,101.17 166.5,100.09 178.31,100.09 180.47,102.25 188.85,102.25 193.67,107.08 214.88,107.08 222.78,114.98 285.12,114.98 285.75,115.61 285.75,127.27 284.73,128.28 205.1,128.28 203.83,129.55 203.83,135.27 203.2,135.9 192.41,135.9 191.13,137.17 191.13,144.41 190.88,144.67 187.71,144.67 185.04,147.33 172.08,147.33 170.31,145.56 168.78,145.56 167.89,144.67 165.61,144.67 164.85,143.91 164.85,129.94
DVDD_DDR on TOP: 264.92,141.37 264.92,137.68 265.43,137.17 270.76,137.17 271.02,137.43 271.02,141.49 270.64,141.87 265.43,141.87
DVDD_DDR on L05_PWR1: 150.5,133.36 170.31,133.36 170.81,132.86 170.81,118.12 169.67,116.98 169.65,116.98 168.91,116.25 168.91,99.07 169.54,98.44 175.89,98.44 177.16,99.71 177.16,100.34 178.14,101.32 185.76,101.32 185.85,101.41 206.17,101.41 210.19,105.42 210.19,113.04 208.28,114.95 206.38,114.95 205.74,115.58 205.74,134 212.09,140.35 243.2,140.35 248.92,146.06 256.54,146.06 259.08,143.52 273.05,143.52 273.69,142.89 273.69,135.27 271.78,133.36 271.78,130.82 271.14,130.19 219.71,130.19 217.17,127.65 217.17,98.44 212.72,93.99 193.04,93.99 192.41,94.63 189.86,94.63 189.23,93.99 184.78,93.99 184.15,93.36 151.13,93.36 150.5,93.99
DVDD_DDR on L06_PWR2: 152.4,137.81 152.4,109.23 153.03,108.6 165.35,108.6 165.35,109.11 165.61,109.36 165.61,112.41 165.86,112.66 166.75,112.66 167,112.92 167,114.31 167.64,114.95 170.18,114.95 170.31,115.08 170.31,119.39 170.31,119.39 170.31,123.71 169.42,124.6 168.27,124.6 167.89,124.98 167.89,128.28 167.26,128.92 165.1,128.92 164.47,129.55 164.47,137.94 163.96,138.44 153.03,138.44
GND_AUD_OSC on BOTTOM, L09_GND4: 184.66,115.48 185.14,115.97 185.17,115.97 185.29,116.09 185.29,116.73 185.8,117.24 189.43,117.24 190.8,115.86 190.8,113.22 191.11,112.92 197.74,112.92 199.77,114.95 199.77,116.63 199.42,116.98 197.13,116.98 197.03,117.08 197.03,117.95 196.16,118.81 189.81,118.81 189.51,118.51 184.73,118.51 183.72,117.49 181.61,117.49 181.48,117.36 181.48,115.71 181.61,115.58 183.26,115.58 183.36,115.48
GND_CAN0 on TOP, L04_GND2, L07_GND3, L09_GND4: 15.42,188.99 15.42,180.63 19.72,176.33 35.23,176.33 35.23,181.9 34.34,182.79 29.11,182.79 27.64,184.27 27.64,209.18 16.15,220.66 7.72,220.66 5.92,218.86 5.92,190.54 7.47,188.99
GND_CAN0 on BOTTOM: 7.75,220.66 7.75,218.15 12.65,218.15 12.65,220.66
GND_CAN0 on L02_GND1: 15.42,188.99 15.42,180.58 19.67,176.33 35.23,176.33 35.23,181.9 34.34,182.79 29.44,182.79 27.64,184.6 27.64,209.18 16.15,220.66 7.72,220.66 5.87,218.81 5.87,190.57 7.44,188.99
GND_CAN1 on TOP, L02_GND1, L04_GND2, L07_GND3, L09_GND4: 6.02,180.2 5.38,179.57 5.38,173.9 5.82,173.47 14.63,173.47 16.28,171.82 16.28,166.49 14.5,164.71 9.27,164.71 9.25,164.73 8.31,164.73 6.08,162.51 6.08,145.58 20.47,145.58 20.47,142.48 25.91,137.05 43,137.05 43,155.23 37.77,155.23 29.85,163.16 29.85,168.29 23.84,174.3 17.46,174.3 11.56,180.2
GND_CAN1 on BOTTOM: 8.23,178.86 8.23,176.42 12.22,176.42 12.22,178.86
GND_DB9 on BOTTOM, L02_GND1, L03_SIG1, L04_GND2, L09_GND4: 17.45,97.4 17.45,104.13 16.18,105.4 8.81,105.4 7.8,106.42 7.8,120.26 9.96,122.42 16.03,122.42 17.2,123.59 17.2,129.02 16.31,129.91 2.24,129.91 1.96,129.63 1.96,97.5 2.69,96.76 16.69,96.76 17.32,97.4
GND_HDMI on BOTTOM, L04_GND2, L07_GND3, L08_SIG2, L09_GND4: 77.29,8.3 77.27,8.32 76.76,8.32 76.76,18.53 81.76,18.53 81.76,18.07 96.47,18.07 97.49,17.06 97.49,9.18 96.6,8.3
GND_OSC on TOP: 78.77,199.46 78.77,199.07 78.89,198.95 79.1,198.95 79.2,198.85 79.2,198.64 79.27,198.57 80.01,198.57 81.84,200.4 83.95,200.4 84.58,199.76 84.58,199.63 85.17,199.05 86,199.05 86.31,198.74 86.31,198.24 86.56,197.98 87.1,197.98 87.4,198.29 87.4,198.97 87.76,199.33 91.11,199.33 91.34,199.56 91.34,200.67 91.64,200.98 92.96,200.98 93.24,201.26 93.24,202.71 92.15,203.8 90.93,203.8 88.54,206.19 85.12,206.19 84.33,205.4 84.33,203.95 83.24,202.86 80.92,202.86 79.96,201.89 79.96,200.17 79.55,199.76 79.07,199.76 ; 2 cut-outs
GND_OSC on L02_GND1: 78.77,199.76 78.77,199.07 78.89,198.95 79.1,198.95 79.2,198.85 79.2,198.64 79.27,198.57 80.01,198.57 81.84,200.4 83.95,200.4 84.58,199.76 84.58,199.63 85.17,199.05 86,199.05 86.31,198.74 86.31,198.24 86.56,197.98 87.1,197.98 87.4,198.29 87.4,198.97 87.76,199.33 91.11,199.33 91.34,199.56 91.34,200.67 91.64,200.98 92.96,200.98 93.24,201.26 93.24,202.71 92.15,203.8 90.93,203.8 88.54,206.19 85.12,206.19 84.33,205.4 84.33,203.95 83.24,202.86 80.92,202.86 79.96,201.89 79.96,200.17 79.55,199.76
GND_PCIE on TOP: 216.66,215.66 216.66,218.58 214.63,220.61 214.63,240.3 216.66,242.33 216.66,245.51 211.2,245.51 210.95,245.25 210.95,220.74 210.19,219.98 206.76,219.98 206.12,219.34 206.12,216.3 206.76,215.66
GND_SDCD on BOTTOM, L02_GND1, L04_GND2, L07_GND3, L08_SIG2, L09_GND4: 231.29,20.18 231.29,8.09 231.52,7.86 248.59,7.86 248.64,7.91 248.64,11.42 247.45,12.61 235.05,12.61 233.73,13.93 233.73,19.88 233.15,20.46 231.57,20.46
GND_SYS on BOTTOM: 165.02,114.11 163.47,114.11 161.98,112.61 157.81,112.61 156.69,113.73 153.54,113.73 151.46,111.65 151.46,106.82 154.13,106.82 154.64,107.33 154.64,107.89 155.02,108.27 157.43,108.27 158.76,109.6 158.76,110.9 159.51,111.65 163.14,111.65 164.74,113.25 164.8,113.25 165.07,113.53 165.07,114.06
GND_SYS on L09_GND4: 165.02,114.11 163.47,114.11 163.3,113.93 163.3,113.5 162.41,112.61 157.81,112.61 156.69,113.73 154.33,113.73 153.72,113.12 152.93,113.12 151.56,111.75 151.56,106.82 154.13,106.82 154.64,107.33 154.64,107.89 155.02,108.27 157.43,108.27 158.76,109.6 158.76,110.9 159.51,111.65 163.14,111.65 164.74,113.25 164.8,113.25 165.07,113.53 165.07,114.06
GND_USB_XDS on TOP: 254.13,11.19 254.13,8.4 265.18,8.4 265.18,11.19
GND_USB_XDS on BOTTOM, L07_GND3, L08_SIG2, L09_GND4: 252.76,15.28 252.76,7.61 252.81,7.56 263.7,7.56 263.86,7.71 263.86,12.49 263.5,12.84 262.1,12.84 259.84,10.58 255.78,10.58 254.99,11.37 254.99,15.33 254.76,15.56 253.03,15.56
GNDSHLD0 on BOTTOM: 1.78,216.4 1.78,181.75 2.62,180.91 11.71,180.91 13.78,182.98 13.78,189.87 11.86,191.78 8.33,191.78 5.74,194.38 5.74,207.71 7.09,209.06 15.16,209.06 16.36,210.25 16.36,215.53 14.35,217.54 2.92,217.54
GNDSHLD1 on BOTTOM: 1.85,172.4 1.85,140.78 2.41,140.22 19.71,140.22 21.01,141.52 21.01,146.19 19.41,147.79 8.56,147.79 5.21,151.14 5.21,162.78 7.9,165.47 14.43,165.47 15.77,166.82 15.77,171.39 11.48,175.68 5.13,175.68
GNDUSB on TOP: 1.96,58.16 2.11,58.31 11.94,58.31 12.7,57.55 12.7,54.88 11.94,54.12 1.96,54.12
GNDUSB on TOP: 1.65,64.4 10.29,64.4 11.05,65.17 11.05,69.18 10.64,69.59 7.44,69.59 7.11,69.26 7.11,68.09 6.35,67.32 1.65,67.32
GNDUSB on L03_SIG1: 5.08,66.82 9.53,66.82 10.54,65.8 10.54,55.77 9.91,55.13 3.43,55.13 2.54,56.02 2.54,66.69 2.79,66.94 4.95,66.94
GNDUSB0 on BOTTOM, L02_GND1, L04_GND2, L07_GND3, L09_GND4: 206.91,19.04 206.91,9.64 206.93,9.62 206.93,8.35 207.45,7.83 225.44,7.83 225.76,8.14 225.76,18 224.41,19.34 220.7,19.34 219.79,18.43 211.53,18.43 210.24,19.73 207.59,19.73
GNDUSB0 on L08_SIG2: 206.91,19.04 206.91,9.64 206.93,9.62 206.93,8.35 207.45,7.83 225.44,7.83 225.76,8.14 225.76,18 224.41,19.34 221.46,19.34 219.99,17.87 212.09,17.87 210.24,19.73 207.59,19.73
GNDUSB1 on BOTTOM, L04_GND2, L07_GND3, L08_SIG2, L09_GND4: 200.74,8.73 200.74,11.8 200.56,11.98 199.39,11.98 199.38,11.97 188.86,11.97 188.7,11.8 188.7,7.69 188.82,7.56 200.63,7.56 200.76,7.69 200.76,8.7
VCC1V2 on TOP: 103.28,55.49 96.65,55.49 96.29,55.13 96.29,46.95 96.24,47 90.04,47 89.94,46.9 89.94,43.6 90.37,43.17 90.37,42.03 90.25,41.9 86.82,41.9 86.56,42.15 86.56,46.85 86.36,47.06 86.36,49.77 86.84,50.26 92.28,50.26 92.76,50.74 92.76,55.56 92.81,55.56 92.81,58.69 93.09,58.97 93.09,58.99 103.84,58.99 106.05,56.78 106.05,52.36 105.97,52.29 104.09,52.29 103.89,52.49 103.89,54.88
VCC1V2_XDS on TOP: 277.34,101.59 277.98,100.95 277.98,99.18 277.85,99.05 275.18,99.05 274.93,98.8 274.93,97.78 274.68,97.53 273.79,97.53 273.66,97.65 273.66,100.73 273.53,100.85 272.29,100.85 272.03,100.6 272.03,99.2 271.91,99.07 270.13,99.07 269.88,99.33 269.88,107.46 270.38,107.96 276.76,107.96 277.34,107.38
VCC1V2_XDS on BOTTOM: 277.34,101.59 277.98,100.95 277.98,99.18 277.85,99.05 275.18,99.05 274.93,98.8 274.93,97.78 274.68,97.53 273.79,97.53 273.66,97.65 273.66,107.76 273.86,107.96 276.76,107.96 277.34,107.38
VCC1V2_XDS_CVDD on TOP: 269.24,95.01 269.24,98.57 272.16,98.57 272.16,95.01
VCC1V2_XDS_CVDD on L05_PWR1: 239.27,53.74 239.52,53.48 240.16,53.48 240.28,53.35 243.33,53.35 243.59,53.61 243.59,54.24 243.71,54.37 244.35,54.37 244.6,54.12 244.86,54.12 245.11,54.37 245.11,56.02 245.24,56.15 246.38,56.15 246.63,55.89 246.63,53.1 246.25,52.72 243.46,52.72 243.46,50.56 243.71,50.31 244.98,50.31 244.98,49.54 244.35,48.91 242.95,48.91 242.57,48.53 242.57,41.54 243.08,41.04 252.86,41.04 254.63,39.26 254.63,33.54 253.49,32.4 228.73,32.4 226.19,34.94 226.19,67.45 228.73,69.99 258.44,69.99 261.49,73.04 261.49,90.82 268.48,97.8 273.3,97.8 275.21,95.9 275.21,62.12 272.8,59.7 239.78,59.7 239.52,59.96 233.3,59.96 232.16,58.82 232.16,46.12 233.81,44.46 237.24,44.46 238.12,45.35 238.12,47.89 237.87,48.15 237.87,50.56 237.11,51.32 237.11,53.35 237.36,53.61 237.87,53.61 237.87,54.5 237.74,54.62 237.36,54.62 236.73,55.26 236.35,55.26 236.35,56.15 238.89,56.15 239.27,55.77
VCC1V2_XDS_PLL on TOP: 243.98,30.25 244.7,29.53 248.64,29.53 249.02,29.91 249.02,33.72 248.39,34.36 244.86,34.36 243.98,33.48
VCC1V2_XDS_PLL on L03_SIG1: 246.68,30.62 246.68,33.37 244.91,33.37 244.91,30.62
VCC1V8_AUD on BOTTOM: 279.02,48.78 279.02,42.94 279.65,42.31 281.69,42.31 281.94,42.56 281.94,48.78 281.69,49.04 279.27,49.04
VCC1V8_WLAN on TOP: 167.69,227.12 167.69,224.58 167.81,224.46 167.81,224.39 168.02,224.17 173.1,224.17 173.91,224.98 173.91,232.32 173.28,232.96 170.61,232.96 169.09,231.43 169.09,227.62 168.71,227.24 167.82,227.24
VCC1V8_WLAN on BOTTOM: 170.43,224.47 170.43,227.14 167.28,227.14 167.28,224.47
VCC1V8_WLAN on BOTTOM: 183.51,236.23 183.51,234.33 184.28,233.57 192.15,233.57 192.79,234.2 192.79,236.23 194.69,238.14 194.69,238.9 194.82,239.03 194.82,241.06 194.18,241.7 191.9,241.7 191.13,240.93 191.13,238.14 189.86,236.87 184.15,236.87
VCC1V8_XDS on TOP: 282.45,85.99 282.45,91.84 282.19,92.09 281.18,92.09 281.05,92.22 281.05,94.5 281.31,94.76 282.07,94.76 282.19,94.63 282.19,93.74 282.32,93.61 282.32,93.23 283.08,92.47 283.34,92.47 283.72,92.09 283.72,91.07 284.1,90.69 288.04,90.69 288.54,90.18 288.54,85.87 288.29,85.61 282.83,85.61
VCC1V8_XDS on L06_PWR2: 271.78,90.82 254.25,90.82 252.98,92.09 252.98,95.14 253.62,95.77 256.29,95.77 256.92,95.14 257.05,95.14 257.81,94.38 285.75,94.38 286.51,93.61 286.51,90.69 287.02,90.18 287.02,88.28 283.84,85.1 277.5,85.1
VCC1V8_XDS_DVDD18 on TOP: 282.07,85.61 282.07,87.9 281.81,88.15 278.26,88.15 278.13,88.03 278.13,85.61 278.38,85.36 281.81,85.36
VCC1V8_XDS_DVDD18 on L05_PWR1: 232.54,57.29 234.31,59.07 272.92,59.07 275.72,61.86 275.72,86.76 277.11,88.15 281.94,88.15 284.73,85.36 284.73,46.62 279.91,41.8 243.97,41.8 243.33,42.43 243.33,47.77 244.22,48.66 244.73,48.66 245.87,49.8 245.87,50.69 244.35,50.69 243.71,51.32 243.71,52.34 246.51,52.34 246.89,52.72 246.89,56.02 246.25,56.66 244.86,56.66 244.86,54.75 244.73,54.62 243.59,54.62 243.46,54.5 243.46,53.99 243.2,53.74 239.9,53.74 239.52,54.12 239.52,56.02 239.27,56.28 236.09,56.28 236.09,54.75 236.35,54.5 237.49,54.5 237.49,53.74 237.36,53.74 236.98,53.35 236.98,50.94 237.62,50.31 237.62,45.48 237.11,44.97 233.3,44.97 232.54,45.73
VCC3V3_AUD on BOTTOM: 273.05,38.62 273.05,34.18 273.56,33.67 275.21,33.67 275.46,33.92 275.46,36.59 275.59,36.72 277.5,36.72 277.75,36.46 277.75,34.81 277.88,34.69 279.02,34.69 279.15,34.81 279.15,35.32 278.89,35.57 278.89,37.1 278.38,37.61 277.37,37.61 277.11,37.86 277.11,38.37 277.24,38.5 280.52,38.5 280.64,38.37 280.64,36.67 280.42,36.44 280.42,32.53 279.53,31.64 274.19,31.64 273.94,31.38 273.94,30.88 275.34,29.48 281.69,29.48 282.19,29.99 282.19,38.88 282.57,39.26 287.27,39.26 287.53,39.51 287.53,41.29 287.02,41.8 278.64,41.8 276.1,39.26 273.69,39.26
VCC3V3_AUD_EXP on TOP: 294.13,148.22 294.13,146.32 294,146.19 294,131.59 295.91,129.68 303.78,129.68 304.29,130.19 304.29,134.63 304.04,134.89 298.96,134.89 297.81,136.03 297.81,147.46 296.93,148.35 294.26,148.35
VCC3V3_BMC on TOP: 143.89,227.47 143.38,226.96 143.38,219.22 143.76,218.84 144.53,218.84 144.78,218.58 144.78,214.77 144.4,214.39 144.4,209.44 144.78,209.06 149.61,209.06 149.99,209.44 149.99,227.09 149.61,227.47
VCC3V3_BMC on L06_PWR2: 177.8,211.34 177.8,247.03 175.89,248.93 11.43,248.93 6.35,243.85 6.35,107.08 7.49,105.93 92.71,105.93 97.54,110.76 97.54,124.6 95,127.14 95,183.4 95.25,183.66 104.27,183.66 105.28,184.67 105.28,218.45 113.16,226.33 123.95,226.33 123.83,226.46 132.08,226.46 147.19,211.34
VCC3V3_BMC on L06_PWR2: 168.02,85.1 176.78,85.1 178.82,87.14 182.75,87.14 183.13,87.52 183.13,91.01 178.5,91.01 176.02,88.53 168.4,88.53 167.89,88.03 167.89,85.23
VCC3V3_CDCM on L05_PWR1: 104.14,97.8 98.43,97.8 97.16,99.07 97.16,101.61 99.06,103.52 120.65,103.52 123.19,100.98 149.22,100.98 149.86,100.34 149.86,92.09 149.22,91.45 149.22,84.47 147.32,82.56 133.35,82.56 132.08,83.83 132.08,90.18 131.44,90.82 108.59,90.82 104.78,94.63 104.78,97.17
VCC3V3_CP2105 on TOP: 15.57,60.06 15.57,56.23 15.63,56.16 15.63,54.74 16.76,53.61 21.34,53.61 21.46,53.74 21.46,56.02 21.21,56.28 20.07,56.28 19.69,55.89 19.69,55.26 19.43,55.01 17.91,55.01 17.78,55.13 17.78,58.05 18.29,58.56 18.29,60.34 18.16,60.47 16.59,60.47 16.28,60.16 15.67,60.16
VCC3V3_DC_CONN on TOP: 200.25,232.91 200.56,232.6 200.56,231.87 200.91,231.51 202.23,231.51 202.39,231.66 202.39,234.36 202.08,234.66 201.63,234.66 201.5,234.79 201.5,235.78 201.17,236.11 199.52,236.11 199.26,235.85 199.26,233.19 199.54,232.91
