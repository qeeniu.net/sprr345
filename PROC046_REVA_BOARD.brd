# Allegro board PROC046_REVA_BOARD.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BUFF_DSSDATA3: length 76.4
  TOP w0.127: v1(155.85,60.23) 156.25,60.63 U81.K6 ; U81.B6 v1(163.05,62.11)
  L03_SIG1 w0.127: v2(178.05,97.04) 178.26,97.04 178.66,96.64 178.66,96.1 178.37,95.81 178.07,95.81 177.1,94.83 177.1,94.42 177.22,94.29 179.2,94.29 179.32,94.16 179.32,93.91 179.2,93.78 177.22,93.78 177.1,93.65 177.1,93.4 177.22,93.27 179.2,93.27 179.32,93.15 179.32,92.89 179.2,92.77 177.22,92.77 177.1,92.64 177.1,91.12 177.22,90.99 177.98,90.99 178.1,90.87 178.1,90.61 177.98,90.49 177.22,90.49 177.1,90.36 177.1,90.11 177.22,89.98 177.98,89.98 178.1,89.85 178.1,89.6 177.98,89.47 177.22,89.47 177.1,89.34 177.1,89.09 177.22,88.96 177.98,88.96 178.1,88.84 178.1,88.58 177.98,88.45 177.22,88.45 177.1,88.33 177.1,88.07 177.22,87.95 177.98,87.95 178.1,87.82 178.1,87.57 177.98,87.44 177.22,87.44 177.1,87.31 177.1,87.06 177.22,86.93 177.98,86.93 178.1,86.8 178.1,86.55 177.98,86.42 177.22,86.42 177.1,86.3 177.1,86.04 177.22,85.91 177.98,85.91 178.1,85.79 178.1,85.53 177.98,85.41 177.22,85.41 177.1,85.28 177.1,85.03 177.22,84.9 177.98,84.9 178.1,84.77 178.1,84.52 177.98,84.39 177.22,84.39 177.1,84.26 177.1,82.28 177.08,82.26 177.08,81.85 177.1,81.83 177.1,81.52 177.08,81.5 177.08,81.09 177.1,81.07 177.1,78.38 165.79,67.07 165.79,63.16 164.11,61.48 163.6,61.48 163.22,61.86 163.22,61.94 v1(163.05,62.11)
  BOTTOM w0.127: v2(178.05,97.04) 178.05,97.85 RA10.5 ; v1(163.05,62.11) 163.05,61.98 162.1,61.03 160.73,61.03 160.34,61.42 156.49,61.42 156.26,61.19 156.26,61.15 156.26,60.63 v1(155.85,60.23)
BUFF_DSSDATA4: length 77.2
  TOP w0.127: v1(155.05,61.03) 155.05,62.91 U81.L5 ; RA7.8 179.46,98.28 180.87,96.87 180.87,94.92 180.77,94.81 v2(180.77,94.5) ; U81.C5 v1(162.25,62.91)
  L03_SIG1 w0.127: v2(180.77,94.5) 179.72,93.45 179.72,88.72 178.35,87.35 178.35,78.95 175.01,75.61 175.01,74.41 174.88,74.28 173.87,74.28 173.75,74.15 173.75,73.9 173.87,73.77 174.88,73.77 175.01,73.65 175.01,73.39 174.88,73.26 173.87,73.26 173.75,73.14 173.75,72.88 173.87,72.76 174.88,72.76 175.01,72.63 175.01,72.23 174.88,72.1 173.62,72.1 173.49,71.97 173.49,71.72 173.62,71.59 174.88,71.59 175.01,71.46 175.01,71.02 174.88,70.89 173.37,70.89 173.24,71.02 173.24,72.4 173.11,72.53 172.86,72.53 172.73,72.4 172.73,71.02 172.6,70.89 172.35,70.89 172.22,71.02 172.22,72.4 172.1,72.53 171.84,72.53 171.72,72.4 171.72,71.02 171.59,70.89 170.29,70.89 166.12,66.72 166.12,63.16 164.21,61.25 163.35,61.25 162.66,61.94 162.66,62.5 v1(162.25,62.91)
  BOTTOM w0.127: v1(162.25,62.91) 161.86,62.51 161.86,62.27 161.86,61.94 161.64,61.72 161.63,61.72 161.62,61.71 161.21,61.71 160.68,62.24 156.08,62.24 155.05,61.22 v1(155.05,61.03)
BUFF_DSSDATA5: length 78.4
  TOP w0.127: v1(155.05,60.23) 155.45,60.63 U81.L6 ; RA7.7 178.82,98.53 180.57,96.77 180.57,95.27 v2(180.42,95.11) ; U81.C6 v1(162.25,62.11)
  L03_SIG1 w0.127: v2(180.42,95.11) 180.86,95.11 181.26,94.71 181.26,94.3 181.21,94.25 181.21,88.11 178.63,85.53 178.63,78.44 175.51,75.33 175.51,75.06 175.64,74.93 176.16,74.93 176.29,74.8 176.29,74.55 176.16,74.42 175.64,74.42 175.51,74.3 175.51,74.04 175.64,73.91 176.16,73.91 176.29,73.79 176.29,73.53 176.16,73.41 175.64,73.41 175.51,73.28 175.51,73.03 175.64,72.9 176.16,72.9 176.29,72.77 176.29,72.52 176.16,72.39 175.64,72.39 175.51,72.26 175.51,69.86 175.14,69.49 174.18,69.49 174.05,69.62 174.05,70.5 173.92,70.63 173.67,70.63 173.54,70.5 173.54,69.62 173.42,69.49 173.16,69.49 173.04,69.62 173.04,70.5 172.91,70.63 172.65,70.63 172.53,70.5 172.53,69.62 172.4,69.49 172.15,69.49 172.02,69.62 172.02,70.5 171.89,70.63 171.64,70.63 171.51,70.5 171.51,69.62 171.38,69.49 171.13,69.49 171,69.62 171,70.5 170.88,70.63 170.62,70.63 170.5,70.5 170.5,69.62 170.37,69.49 169.27,69.49 168.5,68.72 168.5,68.54 168.59,68.45 168.59,68.27 168.41,68.09 168.23,68.09 168.14,68.18 167.96,68.18 167.78,68 167.78,67.82 167.87,67.73 167.87,67.55 167.69,67.37 167.51,67.37 167.42,67.46 167.24,67.46 167.06,67.28 167.06,67.1 167.15,67.01 167.15,66.84 166.97,66.66 166.79,66.66 166.7,66.74 166.52,66.74 166.34,66.56 166.34,63.07 164.3,61.03 163.25,61.03 162.43,61.85 162.43,61.88 162.25,62.06 v1(162.25,62.11)
  BOTTOM w0.127: v1(155.05,60.23) 155.46,60.63 155.46,61.24 156.1,61.88 160.64,61.88 161.04,61.48 161.79,61.48 162.09,61.79 162.09,61.9 162.25,62.06 v1(162.25,62.11)
BUFF_DSSDATA6: length 71.2
  TOP w0.127: U81.D5 v1(161.45,62.91) ; U81.M5 154.25,62.91 v1(154.25,61.03) ; RA7.6 178.31,98.64 180.18,96.77 180.18,95.97 v2(179.86,95.65)
  L03_SIG1 w0.127: v1(161.45,62.91) 161.85,62.51 161.85,60.92 162.43,60.34 164.34,60.34 166.62,62.63 166.62,65.93 169.8,69.1 176.02,69.1 176.53,69.61 176.53,69.94 176.4,70.07 175.89,70.07 175.77,70.2 175.77,70.45 175.89,70.58 176.4,70.58 176.53,70.71 176.53,70.96 176.4,71.09 175.89,71.09 175.77,71.21 175.77,71.47 175.89,71.6 176.4,71.6 176.53,71.72 176.53,75.83 178.9,78.21 178.9,85.41 181.49,88 181.49,90.39 181.5,90.4 181.5,94.89 180.77,95.62 179.88,95.62 v2(179.86,95.65)
  BOTTOM w0.127: v1(154.25,61.03) 154.25,61.18 155.98,62.91 v1(161.45,62.91)
BUFF_DSSDATA7: length 73.3
  TOP w0.127: U81.M6 154.65,60.63 v1(154.25,60.23) ; U81.D6 v1(161.45,62.11) ; RA7.5 177.66,98.64 179.36,96.95 179.36,96.68 v2(179.68,96.36)
  L03_SIG1 w0.127: v2(179.68,96.36) 179.7,96.33 179.83,96.33 180.13,96.03 181.1,96.03 183.39,93.74 183.39,87.5 179.7,83.82 179.7,78.5 177.8,76.6 177.76,76.6 177.5,76.33 177.5,76.29 176.91,75.71 176.91,74.33 177.04,74.21 177.42,74.21 177.55,74.08 177.55,73.83 177.42,73.7 177.04,73.7 176.91,73.57 176.91,69.1 176.53,68.72 169.93,68.72 166.9,65.7 166.9,62.27 164.34,59.7 162.08,59.7 161.04,60.75 161.04,61.69 v1(161.45,62.11)
  BOTTOM w0.127: v1(161.45,62.11) 161.06,62.5 155.9,62.5 154.66,61.26 154.66,61.17 154.66,61.17 154.66,60.63 v1(154.25,60.23)
BUFF_DSSDATA8: length 76.5
  TOP w0.127: U81.E5 159.85,62.91 159.85,61.95 160.15,61.66 v1(160.15,61.03) ; U81.N5 v1(153.45,62.91)
  L03_SIG1 w0.127: v1(160.15,61.03) 159.76,60.63 159.76,59.95 159.64,59.83 158.7,59.83 157.91,60.62 157.59,60.62 156.82,60.62 156.82,60.62 156.49,60.62 156.02,60.62 156.02,60.62 155.69,60.62 155.22,60.62 155.22,60.62 154.89,60.62 154.42,60.62 154.42,60.62 154.09,60.62 153.53,60.62 153.43,60.72 153.42,60.72 153.03,61.1 153.03,62.12 152.95,62.2 152.45,62.2 152.18,61.94 152.18,61.83 151.49,61.13 148.95,61.13 147.83,62.24 147.83,66.51 150.65,69.33 156.9,69.33 157.18,69.61 157.18,69.79 157.13,69.84 157.13,70.02 157.31,70.2 157.49,70.2 157.54,70.15 157.71,70.15 157.89,70.33 157.89,70.51 157.59,70.81 157.59,70.99 157.77,71.17 157.95,71.17 158.25,70.87 158.43,70.87 158.61,71.05 158.61,71.23 158.31,71.53 158.31,71.71 158.49,71.89 158.67,71.89 158.97,71.59 159.15,71.59 159.33,71.77 159.33,71.95 159.03,72.25 159.03,72.43 159.21,72.61 159.39,72.61 159.69,72.31 159.87,72.31 160.05,72.49 160.05,72.67 159.75,72.97 159.75,73.15 159.93,73.33 160.11,73.33 160.41,73.02 160.59,73.02 160.77,73.2 160.77,73.38 160.47,73.69 160.47,73.87 160.64,74.05 160.82,74.05 161.13,73.74 161.31,73.74 161.49,73.92 161.49,74.1 161.18,74.41 161.18,74.58 161.36,74.76 161.54,74.76 161.85,74.46 162.03,74.46 162.21,74.64 162.21,74.82 161.9,75.12 161.9,75.3 162.08,75.48 162.26,75.48 162.56,75.18 162.74,75.18 163.7,76.14 163.7,89.63 v2(165.78,91.7)
  L08_SIG2 w0.127: v1(153.45,62.91) 153.48,62.88 159.13,62.88 160.15,61.86 v1(160.15,61.03)
  BOTTOM w0.127: v2(165.78,91.7) 165.78,91.77 166.26,92.25 RA9.16
BUFF_DSSDATA9: length 77.9
  TOP w0.127: U81.E6 160.55,62.21 160.55,60.63 v1(160.15,60.23) ; U81.N6 153.8,62.51 153.29,61.99 153.29,61.23 153.54,60.97 153.54,57.42 154.05,56.91 154.69,56.91 155.07,57.29 155.07,58.43 153.8,59.7 153.8,61.81 v1(153.85,61.86)
  L03_SIG1 w0.127: v1(153.85,61.86) 153.85,62.43 153.92,62.5 153.92,63.18 153.8,63.31 152.37,63.31 152.25,63.18 152.25,63.07 152.25,63.07 152.25,62.74 152.25,62.74 152.25,62.73 151.56,62.04 151.56,62.02 151.26,61.71 150.22,61.71 149.43,62.5 149.43,67.3 150.8,68.67 158.95,68.67 159.26,68.98 159.44,68.98 159.68,68.74 159.86,68.74 160.04,68.92 160.04,69.1 159.8,69.34 159.8,69.52 159.98,69.7 160.16,69.7 160.4,69.45 160.58,69.45 160.76,69.63 160.76,69.81 160.52,70.05 160.52,70.23 160.7,70.41 160.88,70.41 161.12,70.17 161.3,70.17 161.48,70.35 161.48,70.53 161.24,70.77 161.24,70.95 161.41,71.13 161.59,71.13 161.84,70.89 162.01,70.89 162.19,71.07 162.19,71.25 161.95,71.49 161.95,71.67 162.13,71.85 162.31,71.85 162.55,71.61 162.73,71.61 162.91,71.79 162.91,71.97 162.67,72.21 162.67,72.39 162.85,72.57 163.03,72.57 163.27,72.33 163.45,72.33 163.63,72.51 163.63,72.69 163.39,72.93 163.39,73.11 163.57,73.29 163.75,73.29 163.99,73.05 164.17,73.05 164.35,73.23 164.35,73.41 164.11,73.65 164.11,73.83 165.1,74.82 165.1,89.58 v2(166.34,90.82)
  L08_SIG2 w0.127: v1(153.85,61.86) 157.48,61.86 158.16,61.19 158.16,60.86 158.43,60.59 159.16,60.59 159.19,60.62 159.74,60.62 160.13,60.23 v1(160.15,60.23)
  BOTTOM w0.127: v2(166.34,90.82) 166.34,91.93 166.82,92.41 RA9.15
BUFF_DSSDATA10: length 80.7
  TOP w0.127: v1(159.35,61.03) 159.35,61.29 159.05,61.58 159.05,62.91 U81.F5 ; U81.P5 v1(152.65,62.91)
  L03_SIG1 w0.127: v2(167.84,91.71) 167.33,91.2 166.62,91.2 166.53,91.29 166.5,91.29 166.49,91.3 166.04,91.3 164.47,89.73 164.47,76.01 163.63,75.18 163.63,75 164.2,74.44 164.2,74.26 164.02,74.08 163.84,74.08 163.27,74.64 163.09,74.64 162.91,74.46 162.91,74.28 163.46,73.74 163.46,73.56 163.28,73.38 163.1,73.38 162.55,73.92 162.37,73.92 162.2,73.74 162.2,73.56 162.74,73.02 162.74,72.84 162.56,72.66 162.38,72.66 161.84,73.2 161.66,73.2 161.48,73.02 161.48,72.84 162.02,72.3 162.02,72.12 161.84,71.94 161.66,71.94 161.12,72.48 160.94,72.48 160.76,72.31 160.76,72.13 161.3,71.58 161.3,71.4 161.12,71.22 160.94,71.22 160.4,71.77 160.22,71.77 160.04,71.59 160.04,71.41 160.58,70.86 160.58,70.68 160.4,70.5 160.22,70.5 159.68,71.05 159.5,71.05 159.32,70.87 159.32,70.69 159.87,70.14 159.87,69.96 159.69,69.79 159.51,69.79 158.96,70.33 158.78,70.33 158.6,70.15 158.6,70.1 159.15,69.55 159.15,69.37 158.97,69.19 158.66,69.19 158.24,69.61 158.06,69.61 157.45,69 150.75,69 149.15,67.4 149.15,62.35 150.09,61.41 151.38,61.41 151.9,61.93 151.9,62.05 152.37,62.52 153.14,62.52 153.42,62.24 153.42,61.61 153.59,61.43 157.91,61.43 158.16,61.19 158.16,60.86 158.41,60.61 158.93,60.61 v1(159.35,61.03)
  L08_SIG2 w0.127: v1(159.35,61.03) 159.35,61.64 158.5,62.5 153.16,62.5 152.76,62.91 v1(152.65,62.91)
  BOTTOM w0.127: RA9.12 168.32,92.2 v2(167.84,91.71)
BUFF_DSSDATA11: length 86.3
  TOP w0.102: 152.27,59.32 152.27,59.7 153.03,60.47 153.03,60.72 152.58,61.18 v1(152.58,61.74) ; U81.P6 153.05,61.1 153.29,60.87 153.29,59.37 ; 159.74,61.36 159.74,60.62
  TOP w0.127: 153.29,59.37 153.29,58.18 153.03,57.93 152.53,57.93 152.27,58.18 152.27,58.43 152.15,58.56 150.37,58.56 150.24,58.69 150.24,58.94 150.37,59.07 152.15,59.07 152.27,59.2 152.27,59.32 ; 159.74,60.62 v1(159.35,60.23) ; 159.74,61.36 159.45,61.64 U81.F6
  L03_SIG1 w0.127: v1(152.58,61.74) 151.05,60.21 148.84,60.21 147.45,61.61 147.45,67.58 149.48,69.61 155.57,69.61 155.91,69.94 155.91,70.12 155.81,70.22 155.81,70.4 155.99,70.58 156.17,70.58 156.27,70.48 156.45,70.48 156.63,70.66 156.63,70.84 156.53,70.94 156.53,71.12 156.71,71.29 156.89,71.29 156.98,71.2 157.16,71.2 157.34,71.38 157.34,71.56 157.25,71.65 157.25,71.83 157.43,72.01 157.61,72.01 157.7,71.92 157.88,71.92 158.06,72.1 158.06,72.28 157.97,72.37 157.97,72.55 158.15,72.73 158.33,72.73 158.42,72.64 158.6,72.64 158.78,72.82 158.78,73 158.69,73.09 158.69,73.27 158.87,73.45 159.05,73.45 159.14,73.36 159.32,73.36 159.5,73.54 159.5,73.71 159.41,73.81 159.41,73.99 159.58,74.17 159.76,74.17 159.86,74.07 160.04,74.07 160.22,74.25 160.22,74.43 160.12,74.53 160.12,74.71 160.3,74.89 160.48,74.89 160.58,74.79 160.76,74.79 160.94,74.97 160.94,75.15 160.84,75.25 160.84,75.43 161.02,75.61 161.2,75.61 161.3,75.51 161.48,75.51 161.65,75.69 161.65,75.87 161.56,75.96 161.56,76.14 161.74,76.32 161.92,76.32 162.01,76.23 162.19,76.23 162.37,76.41 162.37,76.59 162.28,76.68 162.28,76.86 162.46,77.04 162.64,77.04 162.73,76.95 162.91,76.95 163.28,77.32 163.28,85.57 163.16,85.7 162.43,85.7 162.31,85.83 162.31,86.08 162.43,86.21 163.16,86.21 163.28,86.34 163.28,86.59 163.16,86.72 162.43,86.72 162.31,86.84 162.31,87.1 162.43,87.22 163.16,87.22 163.28,87.35 163.28,87.61 163.16,87.73 162.43,87.73 162.31,87.86 162.31,88.11 162.43,88.24 163.16,88.24 163.28,88.37 163.28,88.62 163.16,88.75 162.43,88.75 162.31,88.88 162.31,89.13 162.43,89.26 163.16,89.26 163.28,89.38 163.28,90.15 165.35,92.22 166.32,92.22 v2(166.84,91.7)
  L08_SIG2 w0.127: v1(159.35,60.23) 158.96,59.83 158.37,59.83 158.14,60.06 158.14,60.06 158.14,60.5 158.02,60.62 157.91,60.62 156.82,60.62 156.82,60.62 156.49,60.62 156.02,60.62 156.02,60.62 155.69,60.62 155.22,60.62 155.22,60.62 154.89,60.62 154.42,60.62 154.42,60.62 154.09,60.62 153.7,60.62 v1(152.58,61.74)
  BOTTOM w0.127: RA9.14 167.32,92.37 166.84,91.89 v2(166.84,91.7)
BUFF_DSSDATA12: length 80.1
  TOP w0.127: v1(158.55,61.03) 158.55,61.2 158.25,61.5 158.25,62.9 U81.G5 ; U81.R5 v1(151.85,62.91)
  L03_SIG1 w0.127: v2(169.93,90.95) 169.96,90.91 169.96,87.48 170.56,86.88 170.56,82.06 170.43,81.93 169.67,81.93 169.16,81.42 169.16,80.46 169.29,80.33 170.69,80.33 170.81,80.2 170.81,79.95 170.69,79.82 169.29,79.82 169.16,79.69 169.16,79.44 169.29,79.31 170.69,79.31 170.81,79.19 170.81,78.93 170.69,78.81 169.29,78.81 169.16,78.68 169.16,78.42 169.29,78.3 170.69,78.3 170.81,78.17 170.81,77.92 170.69,77.79 169.29,77.79 169.16,77.66 169.16,77.41 169.29,77.28 170.69,77.28 170.81,77.15 170.81,76.9 170.69,76.77 169.29,76.77 169.16,76.65 169.16,76.39 169.29,76.27 169.8,76.27 169.93,76.14 169.93,75.88 169.8,75.76 169.29,75.76 169.16,75.63 169.16,74.82 165.1,70.75 163.7,70.75 160.63,67.68 151.08,67.68 150.5,67.1 150.5,63.57 150.75,63.31 151.31,63.31 151.46,63.46 151.46,63.97 151.64,64.15 154.43,64.15 154.66,63.92 154.66,62.52 155.32,61.86 157.99,61.86 158.55,61.3 v1(158.55,61.03)
  L08_SIG2 w0.127: v1(151.85,62.91) 152.25,62.51 152.77,62.51 153.02,62.26 157.98,62.26 158.55,61.68 v1(158.55,61.03)
  BOTTOM w0.127: v2(169.93,90.95) 170.13,91.15 170.13,92.14 169.89,92.38 RA9.9
BUFF_DSSDATA13: length 80.1
  TOP w0.102: v1(152.58,60.59) 152.21,60.96 152.21,61.13 152.11,61.23 151.66,61.23 151.56,61.13 151.56,59.93 151.45,59.83 151.25,59.83 151.15,59.93 151.15,61.13 151.05,61.23 150.84,61.23 150.74,61.13 150.74,59.93 150.64,59.83 150.44,59.83 150.34,59.93 150.34,61.13 150.23,61.23 149.83,61.23 149.73,61.33 149.73,61.53 149.83,61.64 152.11,61.64 152.2,61.72 152.2,62.45 U81.R6 ; 158.24,59.58 158.97,60.31 158.97,61.29
  TOP w0.127: 158.97,61.29 158.65,61.6 U81.G6 ; v1(157.73,59.58) 158.24,59.58
  L03_SIG1 w0.127: v1(157.73,59.58) 156.84,59.58 156.59,59.83 153.34,59.83 v1(152.58,60.59) 151.43,59.45 148.34,59.45 146.69,61.1 146.69,67.71 148.87,69.89 154.97,69.89 158.93,73.85 158.93,74.03 158.79,74.17 158.79,74.35 158.97,74.53 159.15,74.53 159.29,74.39 159.47,74.39 159.65,74.57 159.65,74.75 159.51,74.89 159.51,75.07 159.69,75.25 159.87,75.25 160.01,75.11 160.19,75.11 160.37,75.29 160.37,75.47 160.23,75.61 160.23,75.79 160.41,75.97 160.59,75.97 160.72,75.83 160.9,75.83 161.08,76.01 161.08,76.19 160.95,76.33 160.95,76.51 161.13,76.69 161.31,76.69 161.44,76.55 161.62,76.55 162.94,77.87 162.94,84.55 161.8,85.69 161.8,89.68 164.72,92.6 168.78,92.6 v2(169.42,91.96)
  BOTTOM w0.127: RA9.10 169.32,92.06 v2(169.42,91.96)
BUFF_DSSDATA14: length 85
  TOP w0.102: 158.17,60.64 158.17,61.21 ; 151.04,62.12 v1(151.05,62.11)
  TOP w0.127: v1(157.75,60.23) 158.17,60.64 ; U81.H6 157.85,61.53 158.17,61.21 ; U81.T6 147.83,62.51 147.32,61.99 147.32,60.21 147.57,59.96 148.39,59.96 148.49,60.06 148.49,61.76 148.84,62.12 151.04,62.12
  L03_SIG1 w0.127: v2(167.67,90.69) 167.67,90.72 165.48,88.53 165.48,88.28 165.61,88.15 165.73,88.15 165.86,88.03 165.86,87.77 165.73,87.64 165.61,87.64 165.48,87.52 165.48,83.51 165.61,83.38 166.48,83.38 166.61,83.25 166.61,83 166.48,82.87 165.61,82.87 165.48,82.75 165.48,82.49 165.61,82.37 166.48,82.37 166.61,82.24 166.61,81.98 166.48,81.86 165.61,81.86 165.48,81.73 165.48,81.48 165.61,81.35 166.48,81.35 166.61,81.22 166.61,80.97 166.48,80.84 165.61,80.84 165.48,80.71 165.48,80.46 165.61,80.33 166.48,80.33 166.61,80.21 166.61,79.95 166.48,79.83 165.61,79.83 165.48,79.7 165.48,79.44 165.61,79.32 166.48,79.32 166.61,79.19 166.61,78.94 166.48,78.81 165.61,78.81 165.48,78.68 165.48,78.43 165.61,78.3 166.48,78.3 166.61,78.17 166.61,77.92 166.48,77.79 165.61,77.79 165.48,77.67 165.48,77.41 165.61,77.29 166.48,77.29 166.61,77.16 166.61,76.9 166.48,76.78 165.61,76.78 165.48,76.65 165.48,76.4 165.61,76.27 166.48,76.27 166.61,76.14 166.61,75.89 166.48,75.76 165.61,75.76 165.48,75.63 165.48,75.38 165.61,75.25 166.48,75.25 166.61,75.13 166.61,74.87 166.48,74.75 165.61,74.75 165.48,74.62 165.48,73.8 160.02,68.34 150.9,68.34 149.81,67.25 149.81,62.75 150.46,62.11 v1(151.05,62.11)
  L08_SIG2 w0.102: v1(157.75,60.23) 157.31,59.78 153.95,59.78 151.93,61.8
  L08_SIG2 w0.127: v1(151.05,62.11) 151.36,61.8 151.93,61.8
  BOTTOM w0.127: v2(167.67,90.69) 167.67,91.12 167.34,91.45 167.34,91.91 167.82,92.39 RA9.13
BUFF_DSSDATA15: length 86.2
  TOP w0.127: U81.H5 157.45,62.91 157.45,61.32 v1(157.75,61.03) ; v1(151.05,62.91) 151.03,62.88 146.43,62.88 146.05,62.5 146.05,61.99 145.8,61.74 144.4,61.74 144.02,62.12 144.02,62.75 144.57,63.31 U81.T5
  L03_SIG1 w0.127: v2(168.91,91.05) 168.96,91 168.96,89.58 166.67,87.29 166.67,83.78 167.13,83.33 167.13,81.81 167.26,81.68 168.14,81.68 168.27,81.56 168.27,81.3 168.14,81.18 167.26,81.18 167.13,81.05 167.13,80.72 167.26,80.6 168.53,80.6 168.66,80.47 168.66,80.22 168.53,80.09 167.26,80.09 167.13,79.96 167.13,79.71 167.26,79.58 168.53,79.58 168.66,79.45 168.66,79.2 168.53,79.07 167.26,79.07 167.13,78.95 167.13,78.69 167.26,78.57 168.53,78.57 168.66,78.44 168.66,78.18 168.53,78.06 167.26,78.06 167.13,77.93 167.13,77.68 167.26,77.55 168.53,77.55 168.66,77.42 168.66,77.17 168.53,77.04 167.26,77.04 167.13,76.91 167.13,76.66 167.26,76.53 168.53,76.53 168.66,76.41 168.66,76.15 168.53,76.03 167.26,76.03 167.13,75.9 167.13,74.69 160.45,68.01 151,68.01 150.22,67.22 150.22,63.31 150.62,62.91 v1(151.05,62.91)
  L08_SIG2 w0.127: v1(151.05,62.91) 151.72,62.24 152.63,62.24 152.83,62.04 152.83,62.04 153.4,61.47 157.31,61.47 v1(157.75,61.03)
  BOTTOM w0.127: RA9.11 168.82,91.79 168.83,91.77 168.83,91.57 168.91,91.49 v2(168.91,91.05)
BUFF_DSSDATA16: length 76.3
  TOP w0.127: U82.A5 v1(138.45,62.52) 138.89,62.08 138.89,61.46 137.9,60.47 134.16,60.47 132.85,61.78 132.85,62.52 U82.G5
  L03_SIG1 w0.127: v1(138.45,62.52) 138.93,62.52 139.34,62.93 139.34,65.09 139.47,65.21 140.37,65.21 140.5,65.34 140.5,65.6 140.37,65.72 139.47,65.72 139.34,65.85 139.34,66.1 139.47,66.23 140.37,66.23 140.5,66.36 140.5,66.61 140.37,66.74 139.47,66.74 139.34,66.87 139.34,67.35 139.45,67.45 140.21,67.45 140.33,67.58 140.33,71.24 142.62,73.52 153.39,73.52 159.56,79.69 159.56,88.47 164.27,93.18 169.41,93.18 170.21,92.39 170.21,91.76 171.55,90.41 171.55,89.96 171.83,89.68 172.34,89.68 v2(172.87,90.21)
  BOTTOM w0.127: RA8.13 172.65,92.35 172.86,92.14 172.86,91.76 172.65,91.55 172.65,91.22 172.56,91.13 172.56,90.7 172.87,90.39 v2(172.87,90.21)
BUFF_DSSDATA17: length 75.1
  TOP w0.127: U82.G6 134.65,60.72 137.46,60.72 v1(138.45,61.72) U82.A6
  L03_SIG1 w0.127: v1(138.45,61.72) 139.15,61.72 139.33,61.54 139.33,60.59 139.46,60.47 139.71,60.47 139.84,60.59 139.84,61.64 139.92,61.72 140.57,61.72 140.72,61.86 140.72,62.12 140.59,62.24 139.7,62.24 139.57,62.37 139.57,62.63 139.7,62.75 140.59,62.75 140.72,62.88 140.72,63.13 140.59,63.26 139.7,63.26 139.57,63.39 139.57,63.64 139.7,63.77 140.59,63.77 140.72,63.9 140.72,64.15 140.59,64.28 139.7,64.28 139.57,64.4 139.57,64.66 139.7,64.78 140.59,64.78 140.77,64.96 140.77,69.3 140.74,69.33 140.74,71.26 142.67,73.19 153.51,73.19 159.84,79.52 159.84,88.36 164.39,92.9 169.29,92.9 169.93,92.27 169.93,91.63 170.43,91.12 v2(170.43,90.44)
  BOTTOM w0.127: v2(170.43,90.44) 171.65,91.65 RA8.15
BUFF_DSSDATA18: length 72.4
  TOP w0.127: U82.B5 v1(137.65,62.52) ; U82.H6 v1(132.45,60.75)
  L03_SIG1 w0.127: v2(174.15,90.31) 173.43,90.31 173.34,90.4 173.34,90.41 173.07,90.68 172.07,90.68 171.16,91.59 171.16,92.54 169.95,93.74 164.04,93.74 159,88.7 159,80.01 153.35,74.36 153.34,74.36 153.31,74.34 141.88,74.34 138.05,70.51 138.05,63.51 138.05,63.51 138.05,63.13 137.65,62.73 v1(137.65,62.52)
  L08_SIG2 w0.127: v1(132.45,60.75) 133.11,60.09 135.78,60.09 137.25,61.55 137.25,62.11 v1(137.65,62.52)
  BOTTOM w0.127: v2(174.15,90.31) 174.42,90.59 174.42,90.99 174.41,91.01 174.41,91.4 174.42,91.41 174.42,92.18 174.4,92.18 174.24,92.33 174.24,92.67 RA8.10
BUFF_DSSDATA19: length 76.8
  TOP w0.127: U82.B6 v1(137.65,61.72) ; U82.H5 132.05,62.52 v1(132.05,60.09)
  L03_SIG1 w0.127: v1(137.65,61.72) 138.05,62.11 138.05,62.7 138.28,62.93 138.29,62.92 138.73,62.92 138.99,63.18 138.99,67.78 139.12,67.91 139.95,67.91 140.08,68.04 140.08,68.29 139.95,68.42 139.12,68.42 138.99,68.54 138.99,68.8 139.12,68.93 139.95,68.93 140.08,69.05 140.08,69.31 139.95,69.43 139.12,69.43 138.99,69.56 138.99,69.81 139.12,69.94 139.95,69.94 140.08,70.07 140.08,70.32 139.95,70.45 139.12,70.45 138.99,70.58 138.99,70.83 139.36,71.2 139.54,71.2 139.66,71.08 139.84,71.08 140.01,71.26 140.01,71.44 139.9,71.56 139.9,71.74 140.07,71.92 140.25,71.92 140.37,71.8 140.55,71.8 140.73,71.98 140.73,72.16 140.61,72.28 140.61,72.46 140.79,72.63 140.97,72.63 141.09,72.52 141.27,72.52 141.45,72.69 141.45,72.87 141.33,72.99 141.33,73.17 142.04,73.88 142.67,73.88 142.85,74.06 143.18,74.06 143.35,73.88 143.68,73.88 143.86,74.06 144.19,74.06 144.37,73.88 144.7,73.88 144.88,74.06 145.21,74.06 145.39,73.88 145.72,73.88 145.89,74.06 146.22,74.06 146.4,73.88 146.73,73.88 146.91,74.06 147.24,74.06 147.42,73.88 147.75,73.88 147.93,74.06 148.26,74.06 148.43,73.88 148.76,73.88 148.94,74.06 149.27,74.06 149.45,73.88 149.78,73.88 149.96,74.06 150.29,74.06 150.47,73.88 150.8,73.88 150.97,74.06 151.3,74.06 151.48,73.88 153.34,73.88 159.28,79.82 159.28,88.59 164.16,93.46 169.63,93.46 170.69,92.41 v2(170.69,91.96)
  BOTTOM w0.127: v1(137.65,61.72) 137.65,61.57 135.86,59.78 132.36,59.78 v1(132.05,60.09) ; v2(170.69,91.96) 171.08,92.36 RA8.16
BUFF_DSSDATA20: length 76.6
  TOP w0.127: U82.C5 v1(136.85,62.52) ; v1(131.25,60.85) 131.25,62.52 U82.J5
  L03_SIG1 w0.127: v1(136.85,62.52) 136.45,62.92 136.45,67.91 136.58,68.04 136.91,68.04 137.03,68.17 137.03,68.42 136.91,68.55 136.58,68.55 136.45,68.67 136.45,68.93 136.58,69.05 136.91,69.05 137.03,69.18 137.03,69.37 137.02,69.38 137.02,69.45 136.91,69.56 136.58,69.56 136.45,69.69 136.45,70.04 141.35,74.94 153.11,74.94 158.45,80.28 158.45,88.93 163.65,94.14 163.81,94.3 170.19,94.3 171.78,92.7 171.78,92.47 171.78,91.84 172.2,91.42 174.61,91.42 174.83,91.2 v2(174.88,91.2)
  L08_SIG2 w0.127: v1(136.85,62.52) 136.45,62.11 136.45,61.53 135.39,60.47 133.7,60.47 132.83,61.34 131.75,61.34 v1(131.25,60.85)
  BOTTOM w0.127: v2(174.88,91.2) 174.88,92.13 174.71,92.3 RA8.9
BUFF_DSSDATA21: length 74
  TOP w0.127: U82.C6 v1(136.85,61.72) ; U82.J6 131.65,60.49 v1(131.25,60.09)
  L03_SIG1 w0.127: v2(173.89,90.95) 173.25,90.95 173.13,91.07 172.08,91.07 171.5,91.66 171.5,92.59 170.07,94.02 163.93,94.02 158.72,88.82 158.72,80.13 153.24,74.64 141.68,74.64 137.26,70.22 137.26,66.68 137.26,66.68 137.26,66.35 137.26,65.88 137.26,65.88 137.26,65.55 137.26,65.08 137.26,65.08 137.26,64.75 137.26,63.48 137.26,63.48 137.26,63.15 137.26,62.68 137.26,62.68 137.26,62.35 137.26,62.12 v1(136.85,61.72)
  BOTTOM w0.127: v1(136.85,61.72) 136.85,61.61 135.5,60.26 133.59,60.26 132.7,61.14 132.25,61.14 131.25,60.15 v1(131.25,60.09) ; RA8.11 173.65,92.37 173.86,92.16 173.86,91.78 173.65,91.57 173.65,91.19 v2(173.89,90.95)
BUFF_DSSDATA22: length 76
  TOP w0.127: v1(130.45,61.61) 130.45,62.52 U82.K5 ; U82.D5 v1(136.05,62.52)
  L03_SIG1 w0.127: v1(136.05,62.52) 136.05,62.77 135.9,62.92 135.89,62.92 135.66,63.15 135.66,63.16 135.65,63.17 135.65,67.12 135.51,67.26 135.2,67.26 135.07,67.39 135.07,67.64 135.2,67.77 135.51,67.77 135.64,67.89 135.64,68.15 135.51,68.28 135.2,68.28 135.07,68.4 135.07,68.66 135.2,68.78 135.51,68.78 135.64,68.91 135.64,69.74 136.01,70.11 136.01,70.41 136.22,70.62 136.52,70.62 136.73,70.83 136.73,71.12 136.94,71.34 137.23,71.34 137.45,71.55 137.45,71.84 137.66,72.06 137.95,72.06 138.17,72.27 138.17,72.56 138.38,72.77 138.67,72.77 138.88,72.99 138.88,73.28 139.1,73.49 139.39,73.49 139.6,73.7 139.6,74 139.81,74.21 140.11,74.21 140.32,74.42 140.32,74.72 140.53,74.93 140.83,74.93 141.22,75.33 142.09,75.33 142.23,75.19 142.59,75.19 142.73,75.33 143.1,75.33 143.24,75.19 143.61,75.19 143.75,75.33 144.12,75.33 144.26,75.19 144.63,75.19 144.77,75.33 145.13,75.33 145.27,75.19 145.64,75.19 145.78,75.33 146.15,75.33 146.29,75.19 146.66,75.19 146.8,75.33 147.17,75.33 147.31,75.19 147.67,75.19 147.81,75.33 148.18,75.33 148.32,75.19 148.69,75.19 148.83,75.33 149.2,75.33 149.34,75.19 149.71,75.19 149.85,75.33 150.21,75.33 150.35,75.19 150.72,75.19 150.86,75.33 151.23,75.33 151.37,75.19 151.74,75.19 151.88,75.33 153.03,75.33 158.17,80.46 158.17,89.05 163.37,94.25 163.69,94.58 170.45,94.58 172.85,92.18 172.85,91.84 172.72,91.71 172.52,91.71 172.4,91.83 v2(172.4,91.95)
  L08_SIG2 w0.127: v1(136.05,62.52) 135.65,62.11 135.65,61.5 135.06,60.9 133.98,60.9 133.11,61.78 130.62,61.78 v1(130.45,61.61)
  BOTTOM w0.127: RA8.14 172.15,92.2 v2(172.4,91.95)
BUFF_DSSDATA23: length 75
  TOP w0.127: v1(130.45,60.09) 130.85,60.49 U82.K6 ; U82.D6 v1(136.05,61.72)
  L03_SIG1 w0.127: v2(173.4,91.97) 170.51,94.86 163.58,94.86 163.09,94.37 157.89,89.17 157.89,80.58 152.91,75.61 140.87,75.61 134.77,69.51 134.77,66.76 134.85,66.68 134.85,63.15 134.84,63.14 135.06,62.92 135.45,62.92 135.66,62.7 135.66,62.68 135.66,62.68 135.66,62.35 136.05,61.95 v1(136.05,61.72)
  BOTTOM w0.127: v2(173.4,91.97) 173.15,92.22 RA8.12 ; v1(136.05,61.72) 136.05,61.67 135.07,60.69 133.81,60.69 132.94,61.56 131.27,61.56 130.45,60.75 v1(130.45,60.09)
BUFF_DSSHSYNC: length 67.3
  TOP w0.127: v2(160.87,82.04) 159.91,82.04 159.38,82.56 R514.1 ; v1(129.65,60.85) 130.05,61.25 U82.L6 ; U82.E6 v1(135.25,61.72)
  L03_SIG1 w0.127: v2(160.87,82.04) 160.87,79.43 153.72,72.28 142.88,72.28 141.55,70.96 141.55,61.14 141.29,60.87 141.29,60.86 140.11,59.68 135.89,59.68 135.25,60.31 v1(135.25,61.72)
  BOTTOM w0.127: v1(135.25,61.72) 135.25,61.67 134.7,61.12 134.09,61.12 133.21,62 130.29,62 130.06,61.77 130.06,61.25 v1(129.65,60.85)
BUFF_DSSPCLK: length 72.6
  TOP w0.127: v1(129.65,61.61) 129.65,62.52 U82.L5 ; U82.E5 v1(135.25,62.52) ; v2(160.83,82.73) 163.14,85.03 163.14,90.64 164.08,91.58 R513.1
  L03_SIG1 w0.127: v2(160.83,82.73) 160.35,82.24 160.35,79.49 153.59,72.74 142.75,72.74 141.12,71.1 141.12,61.31 139.85,60.04 139.24,60.04 138.94,60.34 138.94,61.1 138.81,61.23 138.56,61.23 138.43,61.1 138.43,60.34 138.3,60.21 138.05,60.21 137.92,60.34 137.92,61.1 137.79,61.23 137.54,61.23 137.41,61.1 137.41,60.34 137.29,60.21 137.03,60.21 136.91,60.34 136.91,61.1 136.78,61.23 136.52,61.23 136.4,61.1 136.4,60.34 136.27,60.21 136.02,60.21 135.66,60.57 135.66,61.55 135.66,61.88 135.66,61.88 135.66,61.91 135.25,62.32 v1(135.25,62.52)
  L08_SIG2 w0.127: v1(135.25,62.52) 134.85,62.11 134.85,61.48 134.69,61.32 134.22,61.32 133.34,62.21 130.21,62.21 129.65,61.65 v1(129.65,61.61)
BUFF_DSSVSYNC: length 70.3
  TOP w0.127: v1(128.85,61.61) 128.85,62.52 U82.M5 ; R511.1 160.91,95.22 161.8,94.34 161.8,85.08 v2(160.91,84.19) ; U82.F5 v1(134.45,62.52)
  L03_SIG1 w0.127: v1(134.45,62.52) 134.04,62.1 134.04,59.78 134.87,58.94 140.97,58.94 142.24,60.21 142.24,70.09 143.71,71.57 153.85,71.57 161.65,79.36 161.65,83.45 v2(160.91,84.19)
  L08_SIG2 w0.102: v1(134.45,62.52) 134.35,62.63 129.79,62.63 129.41,62.24 129.41,62.19 129.07,61.85 129.07,61.83 129.06,61.82 129.06,61.81 v1(128.85,61.61)
CDCM_1V8: length 33.8
  TOP w0.203: U62.27 v2(147.45,87.67) ; U62.19 143.25,84.34 v2(142.75,83.83) ; 146.48,89.17 146.48,89.17 v2(147.7,89.17) 147.2,89.67 U62.31 ; U62.24 145.75,85.44 146.18,85.01 v2(146.18,84.98)
  TOP w0.381: C777.1 C778.1 R857.2 ; R896.2 R857.2 ; R857.2 154.84,96.52 154.84,95.93 v2(155.17,95.6)
  L03_SIG1 w0.381: v2(146.18,84.98) 143.89,84.98 v2(142.75,83.83)
  L08_SIG2 w0.381: v2(147.7,89.17) 150.98,92.45 154.1,92.45 155.45,93.79 155.45,95.32 v2(155.17,95.6)
  BOTTOM w0.381: v2(147.7,89.17) 147.7,88.6 147.45,88.34 v2(147.45,87.67) 147.45,85.61 146.81,84.98 v2(146.18,84.98)
CDCM_PDN#: length 144.4
  TOP w0.127: U31.13 54.35,176.87 54.99,176.23 v2(54.99,175.99) ; 142.75,92.9 142.75,94.01 142.25,94.51 v2(142.25,94.79) 141.5,95.54 139.45,95.54 138.58,96.41 137.5,96.41 R474.1
  L03_SIG1 w0.127: v2(142.25,94.79) 141.74,94.27 137.74,94.27 135.23,96.78 132.62,96.78 123.19,106.21 123.19,109.55 90.11,142.64 90.11,142.85 90.07,142.89 90.07,159.2 81.52,167.76 68.18,167.76 64.68,171.26 60.63,171.26 59.31,172.58 58.64,172.58 55.51,175.72 55.26,175.72 v2(54.99,175.99)
CDCM_RST: length 135.9
  TOP w0.127: U33.20 61.48,175.74 v2(60.98,176.24) ; U62.44 v2(142.25,93.77)
  L03_SIG1 w0.127: v2(142.25,93.77) 142.75,93.28 143.46,93.28 143.75,93.57 143.75,95 143.1,95.65 137.2,95.65 135.53,97.31 135.52,97.31 135.48,97.35 132.84,97.35 124.05,106.14 124.05,110.09 90.86,143.29 90.86,159.25 80.95,169.15 69.88,169.15 66.37,172.66 63.55,172.66 60.98,175.23 v2(60.98,176.24)
  BOTTOM w0.127: C637.1 142.25,92.62 v2(142.25,93.77)
CDCM_SPI_CLK: length 124.9
  TOP w0.127: v2(137.65,90.7) 138.18,90.17 U62.5 ; U30.13 v2(79.62,174.33)
  L08_SIG2 w0.127: v2(79.62,174.33) 78.79,173.5 78.79,172.74 78.75,172.69 78.75,161.66 78.75,161.19 105.68,134.26 108.36,131.58 108.36,97.6 108.74,97.21 115.35,90.6 137.56,90.6 v2(137.65,90.7)
CDCM_SPI_CS0: length 137.4
  TOP w0.127: v2(138.43,90.69) 138.45,90.67 U62.4 ; U31.11 v2(51.69,175.57)
  L03_SIG1 w0.127: v2(138.43,90.69) 137.93,91.19 135.29,91.19 123.63,102.85 123.63,104.63 121.65,106.61 121.65,106.65 121.36,106.94 121.32,106.94 89.79,138.47 89.79,159.09 81.4,167.48 68.07,167.48 64.56,170.98 59.48,170.98 59.01,171.45 58.1,171.45 56.69,172.86 54.4,172.86 v2(51.69,175.57)
CDCM_SPI_MISO: length 122.5
  TOP w0.127: U30.11 v2(79.62,173.03) ; v2(137.65,91.7) 138.15,91.2 138.78,91.2 138.81,91.17 U62.3
  L08_SIG2 w0.127: v2(137.65,91.7) 136.61,91.7 136.49,91.82 133.22,91.82 133.17,91.77 117.75,91.77 115.9,93.63 113.01,93.63 108.74,97.9 108.74,131.74 106.06,134.42 79.13,161.35 79.13,172.53 v2(79.62,173.03)
CDCM_SPI_MOSI: length 122.8
  TOP w0.127: v2(138.54,91.7) 139.5,91.7 U62.2 ; U30.12 v2(80.4,173.68)
  L08_SIG2 w0.127: v2(138.54,91.7) 138.08,92.16 133.16,92.16 133.06,92.05 117.82,92.05 116,93.87 113.11,93.87 108.98,98 108.98,131.84 106.3,134.52 80.87,159.95 80.87,173.21 v2(80.4,173.68)
CDCM_SYNC#: length 149
  TOP w0.127: R475.2 139.61,95.82 141.94,95.82 142.75,95.01 142.75,94.5 143.25,94 v2(143.25,93.77) U62.42 ; U31.12 51.7,176.22 v2(51.05,176.87)
  L03_SIG1 w0.127: v2(143.25,93.77) 142.75,94.28 142.75,95.01 142.39,95.37 137.13,95.37 135.43,97.07 132.73,97.07 125.81,103.99 125.81,104.05 123.6,106.26 123.6,109.49 90.35,142.74 90.35,159.32 81.63,168.04 68.3,168.04 64.8,171.54 62.36,171.54 61.04,172.86 58.81,172.86 57.73,173.93 57.73,174.18 55.36,176.56 51.37,176.56 v2(51.05,176.87)
CLK2_SI_MODE0: length 3.4
  TOP w0.127: R483.1 v2(138.81,92.98) 138.81,92.3 138.94,92.17 U62.1
  BOTTOM w0.127: R483.1 v2(138.81,92.98)
CLK2_SI_MODE1: length 9.3
  TOP w0.127: R479.1 136.7,94.79 v2(140.25,94.79) 140.75,94.29 U62.47
  BOTTOM w0.127: v2(140.25,94.79) 136.7,94.79 R479.1
CLK32KOUT: length 19.7
  TOP w0.102: U32.F4 v2(244.6,174.33)
  L03_SIG1 w0.127: TP101.1 230.96,173.57 243.85,173.57 v2(244.6,174.33)
  BOTTOM w0.127: TP101.1 228.25,176.28 R674.1
CLK_REF_SEL: length 147.9
  TOP w0.127: U62.6 137.93,89.67 v2(137.67,89.93) 136.8,89.93 136.41,90.32 R485.2 ; U33.16 63.48,174.99 63.42,175.04 63.42,175.08 63.49,175.14 63.49,175.92 v2(63.04,176.37)
  L03_SIG1 w0.127: v2(63.04,176.37) 63.04,176.37 63.04,176.37 63.17,176.24 63.86,176.24 70.39,169.71 81.23,169.71 91.47,159.48 91.47,144.9 122.71,113.65 122.71,112.05 124.46,110.3 124.46,106.64 132.36,98.74 134.7,98.74 137.21,96.23 144.81,96.23 145.82,95.21 145.82,93.99 144.65,92.83 143.23,92.83 140.33,89.93 v2(137.67,89.93)
  BOTTOM w0.127: R485.2 136.41,90.32 136.8,89.93 v2(137.67,89.93)
COM8_AUD_CLK: length 79.2
  TOP w0.127: U125.4 183.41,211.06 v2(183.01,210.66) ; U64.4 198.53,148.7 v2(198.12,149.11)
  L03_SIG1 w0.127: v2(199.19,179.03) 199.19,180.74 197.18,182.74 197.18,195.26 184.61,207.84 184.61,209.06 v2(183.01,210.66)
  L08_SIG2 w0.127: v2(199.19,179.03) 199.31,178.91 199.31,178.09 194.74,173.52 194.74,163.29 201.14,156.89 201.14,153.55 198.12,150.52 v2(198.12,149.11)
COM8_AUD_FSYNC: length 78.8
  TOP w0.127: U125.5 184.06,212.35 184.12,212.29 v2(184.12,211.11) ; U64.5 v2(199.18,148.99)
  L03_SIG1 w0.127: v2(184.12,211.11) 185.22,210.02 185.22,208.09 197.59,195.72 197.59,183.07 200.23,180.43 v2(200.23,179.29)
  L08_SIG2 w0.127: v2(199.18,148.99) 199.11,149.06 199.11,150.67 201.52,153.08 201.52,157.16 195.22,163.46 195.22,173.09 199.77,177.64 199.77,178.83 v2(200.23,179.29)
COM8_BUFF_CLK_DIR: length 6.1
  TOP w0.127: R490.2 R491.2 195.12,146.01 195.45,145.68 196.98,145.68 197.23,145.94 U64.2
COM8_BUFF_DAT_DIR: length 4.4
  TOP w0.127: R913.2 R912.2 197.88,144.83 U64.3
COM8_BUFF_EN: length 134.7
  TOP w0.127: v2(183.92,177.79) 183.67,177.54 173.69,177.54 151.08,200.14 151.08,245.43 148.95,247.56 SW11.2 145.13,248.82 v2(145.44,249.14) ; U64.14 197.88,151.61 197.87,151.59 197.87,151.53 197.74,151.4 197.44,151.4 197.23,151.61 U64.15 197.23,154.8 196.57,155.46 v2(190.02,155.46)
  L03_SIG1 w0.127: v2(183.92,177.79) 184.1,177.61 184.1,160.94 189.57,155.46 v2(190.02,155.46)
  BOTTOM w0.127: R750.2 v2(145.44,249.14)
COM8_MCASP2AXR1: length 71.1
  TOP w0.127: v2(210.34,189.65) 210.87,189.12 210.87,166.36 205.5,160.99 U135.4 ; v2(195,211.95) 195,211.96 U128.4
  BOTTOM w0.127: v2(195,211.95) 195.31,211.64 195.31,204.72 195.3,204.71 195.3,204.05 209.7,189.65 v2(210.34,189.65)
COM8_MCASP2AXR4: length 79.1
  TOP w0.127: v2(200.53,150) 200.53,149.47 199.83,148.77 U64.6 ; v2(185.62,211.11) 184.71,212.03 U125.6
  L03_SIG1 w0.127: v2(201.22,180.2) 198.15,183.28 198.15,195.9 185.62,208.42 v2(185.62,211.11)
  L08_SIG2 w0.127: v2(200.53,150) 200.53,151.55 201.85,152.87 201.85,157.83 195.53,164.15 195.53,172.48 200.76,177.71 200.89,177.71 200.89,179.87 v2(201.22,180.2)
COM8_MMC1_CLK: length 63
  TOP w0.127: v2(211.1,213.65) 210.44,213 U142.1 ; J2.20 v2(189.1,238.61) 189.42,238.29 190.72,238.29 192.02,236.99 R58.2
  L08_SIG2 w0.127: 190.2,237.61 190.25,237.61 190.37,237.48 195.91,237.48 197.98,235.41 197.98,228.13 206.95,219.16 207.13,219.16 208.46,220.49 208.64,220.49 208.82,220.31 208.82,220.13 207.49,218.8 207.49,218.62 207.67,218.44 207.85,218.44 209.18,219.77 209.35,219.77 209.53,219.59 209.53,219.41 208.21,218.08 208.21,217.9 208.39,217.72 208.57,217.72 209.89,219.05 210.07,219.05 210.25,218.87 210.25,218.69 208.93,217.36 208.93,217.18 209.11,217.01 209.29,217.01 210.61,218.33 210.79,218.33 210.97,218.15 210.97,217.97 209.65,216.65 209.65,216.47 211.53,214.58 211.53,214.09 v2(211.1,213.65) ; 190.2,237.61 189.19,238.61 v2(189.1,238.61) 190.1,237.61 190.2,237.61
COM8_MMC1_CMD: length 60.2
  TOP w0.127: U142.3 210.16,211.7 211.56,213.1 211.56,213.91 v2(211.05,214.42) ; J2.24 v2(187.83,238.61) 188.55,237.89 189.6,237.89 190.5,236.99 R57.2
  L08_SIG2 w0.127: v2(211.05,214.42) 207.19,218.28 206.71,218.28 202.88,222.1 202.7,222.1 201.94,221.34 201.76,221.34 201.58,221.52 201.58,221.7 202.34,222.46 202.34,222.64 202.16,222.82 201.98,222.82 201.22,222.06 201.04,222.06 200.86,222.24 200.86,222.42 201.62,223.18 201.62,223.36 201.44,223.54 201.26,223.54 200.5,222.78 200.32,222.78 200.14,222.96 200.14,223.14 200.9,223.9 200.9,224.08 200.72,224.26 200.55,224.26 199.78,223.5 199.61,223.5 199.43,223.68 199.43,223.86 200.19,224.62 200.19,224.8 200.01,224.98 199.83,224.98 199.07,224.22 198.89,224.22 198.71,224.4 198.71,224.58 199.47,225.34 199.47,225.51 199.29,225.69 199.11,225.69 198.35,224.93 198.17,224.93 197.99,225.11 197.99,225.29 198.75,226.05 198.75,226.23 195,229.99 195,233.64 194.46,234.18 194.46,235.45 193.46,236.45 190.84,236.45 190.07,237.23 189.22,237.23 v2(187.83,238.61)
COM8_MMC1_DAT0: length 60.6
  TOP w0.127: R56.2 188.98,236.99 188.2,237.76 187.96,237.76 187.63,238.09 187.62,238.09 187.31,238.39 187.31,238.41 187.2,238.52 v2(187.2,239.03) J2.26 ; v2(209.41,215.01) 211.28,215.01 211.8,214.49 211.8,211.94 210.91,211.05 U142.4
  L08_SIG2 w0.127: v2(209.41,215.01) 208,216.42 204.98,216.42 196.01,225.39 196.01,225.57 197.07,226.62 197.07,226.8 196.89,226.98 196.71,226.98 195.65,225.93 195.48,225.93 195.3,226.11 195.3,226.29 196.35,227.34 196.35,227.52 196.17,227.7 195.99,227.7 194.94,226.65 194.76,226.65 194.58,226.82 194.58,227 195.63,228.06 195.63,228.24 195.45,228.42 195.27,228.42 194.22,227.36 194.04,227.36 193.86,227.54 193.86,227.72 194.91,228.77 194.91,228.95 194.73,229.13 194.55,229.13 193.5,228.08 193.32,228.08 189.33,232.07 189.33,234.3 189.43,234.41 189.43,236.13 187.25,238.32 187.25,238.98 v2(187.2,239.03)
COM8_MMC1_DAT1: length 59.2
  TOP w0.127: R55.2 187.45,237.72 v2(186.56,238.61) J2.28 ; U142.5 210.84,210.4 212.04,211.6 212.04,214.59 211.16,215.47 208.93,215.47 v2(208.36,214.91)
  L08_SIG2 w0.127: v2(186.56,238.61) 188.09,237.08 188.09,234.51 188.85,233.75 188.85,230.8 192.87,226.78 193.05,226.78 193.38,227.11 193.56,227.11 193.74,226.93 193.74,226.75 193.41,226.42 193.41,226.24 194.04,225.61 194.21,225.61 194.74,226.14 194.92,226.14 195.1,225.96 195.1,225.78 194.57,225.25 194.57,225.07 194.75,224.9 194.93,224.9 195.46,225.42 195.64,225.42 195.82,225.24 195.82,225.06 195.29,224.54 195.29,224.36 195.47,224.18 195.65,224.18 196.18,224.7 196.36,224.7 196.54,224.52 196.54,224.34 196.01,223.82 196.01,223.64 196.19,223.46 196.37,223.46 196.9,223.98 197.08,223.98 197.26,223.81 197.26,223.63 196.73,223.1 196.73,222.92 196.91,222.74 197.09,222.74 197.61,223.27 197.79,223.27 197.97,223.09 197.97,222.91 197.45,222.38 197.45,222.2 203.73,215.91 207.36,215.91 v2(208.36,214.91)
COM8_MMC1_DAT2: length 59.6
  TOP w0.127: v2(208.31,214.14) 207.77,214.67 207.77,215.28 208.2,215.71 211.26,215.71 212.28,214.69 212.28,211.48 210.55,209.75 U142.6 ; J2.30 v2(185.93,239.03) R54.2
  L08_SIG2 w0.127: v2(208.31,214.14) 207.16,215.28 203.97,215.28 198.32,220.94 198.14,220.94 197.9,220.69 197.72,220.69 197.54,220.87 197.54,221.05 197.78,221.3 197.78,221.47 197.6,221.65 197.42,221.65 197.18,221.41 197,221.41 196.82,221.59 196.82,221.77 197.06,222.01 197.06,222.19 196.88,222.37 196.7,222.37 196.46,222.13 196.28,222.13 196.1,222.31 196.1,222.49 196.34,222.73 196.34,222.91 196.16,223.09 195.98,223.09 195.74,222.85 195.56,222.85 195.38,223.03 195.38,223.21 195.62,223.45 195.62,223.63 195.44,223.81 195.26,223.81 195.02,223.57 194.84,223.57 194.66,223.75 194.66,223.93 194.91,224.17 194.91,224.35 194.73,224.53 194.55,224.53 194.3,224.29 194.12,224.29 193.94,224.47 193.94,224.65 194.19,224.89 194.19,225.07 194.01,225.25 193.83,225.25 193.59,225 193.41,225 193.23,225.18 193.23,225.36 193.47,225.61 193.47,225.79 188.47,230.79 188.47,232.9 186.89,234.48 186.89,236.82 185.88,237.84 185.88,238.98 v2(185.93,239.03)
COM8_MMC1_DAT3: length 59.9
  TOP w0.127: R53.2 184.4,237.72 v2(185.29,238.61) J2.32 ; v2(209.35,214.33) 208.7,213.68 207.57,213.68 207.19,214.06 207.19,215.2 207.95,215.97 211.35,215.97 212.52,214.8 212.52,211.37 210.25,209.1 U142.7
  L08_SIG2 w0.127: v2(185.29,238.61) 185.29,234.1 185.98,233.42 185.98,232.09 203.17,214.9 207.2,214.9 207.85,214.25 207.85,213.95 208.12,213.68 208.7,213.68 v2(209.35,214.33)
COM_AUD_CLK: length 4.7
  TOP w0.127: R51.1 181.23,236.99 180.56,237.66 180.24,237.66 178.94,238.95 J2.52
COM_AUD_FSYNC: length 4.2
  TOP w0.127: J2.54 178.31,238.93 179.7,237.53 R50.1
COM_AUD_IN: length 3.8
  TOP w0.127: J2.56 177.67,238.27 178.18,237.76 R49.1
COM_AUD_OUT: length 3.8
  TOP w0.127: J2.58 177.04,237.91 176.66,237.53 R48.1
COM_BTRST: length 4.8
  TOP w0.127: J2.89 163.7,247.18 163.35,246.83 162.89,246.83 v2(162.84,246.88)
  BOTTOM w0.127: v2(162.84,246.88) 162.84,248.35 163.02,248.53 163.66,248.53 R590.2
COM_BTUARTCTS: length 4.1
  TOP w0.127: J2.70 170.05,238.52 170.56,238.01 R61.1
COM_BTUARTDEBUG: length 7.5
  TOP w0.127: TP31.1 165.15,237.94 165.35,238.14 167.26,238.14 168.15,239.03 J2.76
COM_BTUARTRTS: length 4
  TOP w0.127: J2.72 169.42,238.39 169.04,238.01 R60.1
COM_BTUARTRX: length 4.4
  TOP w0.127: J2.68 170.69,238.68 172.08,237.28 R62.1
COM_BTUARTTX: length 5.5
  TOP w0.127: J2.66 171.32,238.77 172.08,238.01 173.35,238.01 173.61,237.76 R63.1
COM_GPIO9: length 8.6
  TOP w0.127: TP30.1 163.19,237.89 163.96,238.65 166.88,238.65 167.51,239.28 J2.78
COM_GPIO10: length 4.7
  TOP w0.127: TP33.1 158.75,237.25 160.53,239.03 J2.100
COM_GPIO11: length 3.4
  TOP w0.127: J2.96 161.8,237.95 161.67,237.82 TP35.1
COM_GPIO12: length 3.9
  TOP w0.127: TP34.1 161.16,238.52 J2.98
COM_SLOW_CLK: length 4.3
  TOP w0.127: v2(195.78,249.8) 195.05,249.8 194.82,249.57 J2.1
  BOTTOM w0.127: R593.2 194.94,249.32 195.43,249.8 v2(195.78,249.8)
COM_WL_IRQ: length 5.7
  TOP w0.127: J2.34 v2(184.66,239.03) ; R52.2 v2(182.88,237.89)
  BOTTOM w0.127: v2(184.66,239.03) 184.02,239.03 v2(182.88,237.89) R52.2
COM_WL_RS232_RX: length 14.2
  TOP w0.127: TP25.1 200.28,242.97 193.29,242.97 191.01,245.25 191.01,248.49
COM_WL_RS232_TX: length 12.9
  TOP w0.127: J2.11 191.64,247.23 191.41,247 191.41,246.19 191.92,245.68 192.66,245.68 192.94,245.97 196.77,245.97 198.12,244.62 200.15,244.62 TP26.1
COM_WL_RST: length 4
  TOP w0.127: J2.4 194.18,238.55 195.2,237.53 R59.1
COM_WL_UART_DBG: length 15.3
  TOP w0.127: J2.15 190.37,244.87 192.79,242.46 200.02,242.46 TP23.1
CP2105_DM: length 18
  TOP w0.104: J23.2 v2(8.68,61.9) ; v2(16.08,60.49) 16.46,60.87 17.23,60.87 17.37,60.72 17.96,60.72 ; U73.2 13.82,61.1 13.69,61.23 12.63,61.23 12.55,61.15 12.55,60.88 v2(12.57,60.86)
  BOTTOM w0.104: v2(16.08,60.49) 15.72,60.85 14.27,60.85 13.88,61.23 12.93,61.23 v2(12.57,60.86) 12.18,61.25 11.88,61.25 11.78,61.14 11.78,60.8 11.67,60.7 11.46,60.7 11.36,60.8 11.36,61.14 11.26,61.25 10.43,61.25 10.4,61.28 10.4,61.28 9.01,62.67 8.02,62.67 7.84,62.49 7.84,61.82 8.06,61.6 8.39,61.6 v2(8.68,61.9)
CP2105_DP: length 17.9
  TOP w0.104: U73.1 13.82,61.6 13.69,61.47 12.61,61.47 12.57,61.51 12.57,61.83 v2(12.57,61.84) ; U74.3 17.37,61.22 17.24,61.1 16.44,61.1 v2(16.08,61.46) ; J23.3 v2(8.68,61.1)
  BOTTOM w0.104: v2(8.68,61.1) 8.42,61.37 7.96,61.37 7.61,61.72 7.61,62.59 7.93,62.91 9.1,62.91 10.53,61.48 12.21,61.48 12.57,61.84 v2(12.57,61.84) 12.94,61.47 13.98,61.47 14.36,61.08 15.7,61.08 v2(16.08,61.46)
CPLD_A0: length 42.7
  TOP w0.127: U9.H7 v2(240.26,70.44) 239.75,70.94 239.75,82.92 242.42,85.59 U12.2
  L08_SIG2 w0.102: 241.17,68.7 240.64,69.23 239.9,69.23 239.7,69.43 239.7,70.25 239.89,70.44 v2(240.26,70.44)
  L08_SIG2 w0.127: 241.17,68.7 241.25,68.62 241.25,68.04 241.26,68.02 241.26,68.01 243.24,66.03 243.26,66.03 243.36,65.93 245.87,65.93 249.68,62.12 250.95,62.12 252.27,60.8 v2(252.27,59.25)
  BOTTOM w0.127: RA14.6 v2(252.27,59.25)
CPLD_A1: length 48.3
  TOP w0.127: v2(242.87,68.44) 242.01,69.31 242.01,70.07 U9.H8 ; v2(243.22,88.67) U12.3
  L08_SIG2 w0.127: v2(252.27,58.09) 252.79,57.57 253.77,57.57 254.13,57.93 254.13,60.82 247.88,67.07 243.71,67.07 243.52,67.26 243.52,67.79 v2(242.87,68.44)
  BOTTOM w0.102: 242.75,76.98 242.44,76.67 242.44,76.61 242.44,76.61 242.44,76.27 242.45,76.26 242.45,69.42 242.44,69.41 242.44,68.88 242.62,68.7
  BOTTOM w0.127: 242.75,76.98 245.82,80.05 245.82,84.5 243.22,87.1 v2(243.22,88.67) ; RA14.8 v2(252.27,58.09) ; 242.62,68.7 v2(242.87,68.44)
CPLD_A2: length 50.1
  TOP w0.127: v2(242.04,68.39) 242.04,68.84 241.7,69.18 241.7,69.58 U9.J8 ; U12.5 v2(244.82,88.62)
  L08_SIG2 w0.127: v2(242.04,68.39) 242.4,68.03 242.4,67.87 243.59,66.69 247.65,66.69 249.55,64.79 249.82,64.79 250.04,64.56 250.04,64.3 250.27,64.07 250.54,64.07 250.76,63.85 250.76,63.58 250.99,63.35 251.26,63.35 251.48,63.13 251.48,62.86 253.41,60.93 253.41,60.67 253.54,60.55 253.76,60.55 253.89,60.42 253.89,60.17 253.76,60.04 253.54,60.04 253.41,59.91 v2(253.41,59.25)
  BOTTOM w0.102: 241.74,68.7 241.68,68.75 241.68,70.62 240.84,71.47 240.84,71.81 241.01,71.98 241.01,72.11 242.15,73.26 242.15,76.98
  BOTTOM w0.127: RA14.5 252.76,59.9 v2(253.41,59.25) ; 241.74,68.7 v2(242.04,68.39) ; 242.15,76.98 245.54,80.37 245.54,84.19 242.9,86.83 242.9,88.25 242.75,88.41 242.75,89.12 243.03,89.4 244.04,89.4 v2(244.82,88.62)
CPLD_A3: length 46.6
  TOP w0.127: U12.6 245.62,88.71 243.29,86.39 243.29,85.7 v2(242.29,84.7) ; U9.J7 240.31,69.64 v2(240.28,69.66)
  L08_SIG2 w0.102: v2(240.28,69.66) 240.74,69.66 241.54,68.86 241.54,68.7
  L08_SIG2 w0.127: 241.54,68.7 241.54,68.12 243.36,66.31 247.4,66.31 252.86,60.85 252.86,58.52 v2(253.29,58.09)
  BOTTOM w0.102: 241.87,76.98 241.87,73.28 240.8,72.21 240.8,72.06 240.63,71.89 240.63,71.38 240.8,71.21 240.8,70.18 v2(240.28,69.66)
  BOTTOM w0.127: RA14.7 252.64,58.74 v2(253.29,58.09) ; v2(242.29,84.7) 242.29,84.01 243.13,83.17 243.13,78.35 241.87,77.09 241.87,76.98
CPLD_BIO_0: length 46.7
  TOP w0.127: U12.42 237.88,94.39 237.46,93.97 235.86,93.97 235.31,93.41 235.31,93 v2(235.58,92.72)
  BOTTOM w0.127: v2(235.58,92.72) 236.27,92.04 246.54,92.04 249.4,89.19 249.4,85.19 247.98,83.77 247.98,76.18 247.19,75.39 247.19,72.11 242.78,67.7 242.45,67.7 242.19,67.44 R91.1
CPLD_BIO_1: length 62.4
  TOP w0.127: U12.43 237.81,93.59 237.45,93.23 236.87,93.23 236.74,93.36 v2(236.3,93.36)
  BOTTOM w0.127: v2(236.3,93.36) 236.64,93.02 252.55,93.02 255.93,89.63 255.93,75.91 249.84,69.81 247.22,69.81 246.26,68.85 244.72,68.85 243.29,67.42 243.29,64.37 242.28,63.35 242.28,61.98 241.53,61.23 RA13.7
CPLD_BIO_2: length 61
  TOP w0.127: v2(236.73,92.57) 237.04,92.89 238.98,92.89 239.08,92.79 U12.44
  BOTTOM w0.127: v2(236.73,92.57) 252.65,92.57 255.69,89.53 255.69,76.09 249.72,70.12 247.14,70.12 246.12,69.1 244.62,69.1 244.52,68.99 244.46,68.99 243.01,67.54 243.01,64.59 242,63.58 242,62.2 241.02,61.23 RA13.6
CPLD_BIO_3: length 33.4
  TOP w0.127: U12.1 241.62,88.12 241.68,88.05 R126.1 240.2,87.41 239.39,86.6 239.39,69.86 240.13,69.13 240.13,68.19 240.03,68.09 240.03,63.23 v2(241.02,62.24)
  BOTTOM w0.127: v2(241.02,62.24) 240.37,61.59 RA13.5
CPLD_BIO_4: length 62.2
  TOP w0.127: U12.41 v2(237.49,95.19) 236.9,95.19 236.34,94.63 R148.1
  BOTTOM w0.127: v2(237.49,95.19) 239.32,93.36 252.55,93.36 256.17,89.73 256.17,75.81 249.94,69.57 247.32,69.57 246.29,68.54 244.81,68.54 243.57,67.31 243.57,64.15 243.41,63.99 243.41,63.97 242.57,63.13 242.57,62.75 242.56,62.74 242.56,61.48 242.18,61.1 RA13.8
CPLD_CSN: length 32.2
  TOP w0.127: R93.1 v2(248.77,67.59) ; U12.8 v2(247.22,88.74)
  L08_SIG2 w0.127: v2(247.22,88.74) 247.9,89.42 249.86,89.42 250.7,88.58 250.7,86.07 253.21,83.56 253.21,72.04 v2(248.77,67.59)
  BOTTOM w0.127: R614.1 249.08,66.82 249.08,67.28 v2(248.77,67.59)
CPLD_D0: length 35.7
  TOP w0.127: U9.A8 242.63,77.03 243.05,77.03 243.81,76.27 244.58,76.27 245.21,75.63 246.48,75.63 246.49,75.64 RA2.1 247.04,76.1 v2(247.48,76.54) ; v2(237.49,96.79) U12.39
  L03_SIG1 w0.127: v2(237.49,96.79) 239.52,94.76 239.52,82.08 245.12,76.48 247.43,76.48 v2(247.48,76.54)
CPLD_D1: length 32.2
  TOP w0.127: RA2.3 v2(245.72,74.49) 245.07,74.49 244.32,75.24 U9.B9 ; v2(237.49,95.99) U12.40
  L03_SIG1 w0.127: v2(237.49,95.99) 238.89,94.59 238.89,82.29 245.72,75.45 v2(245.72,74.49)
CPLD_I/O_10: length 4.8
  TOP w0.127: R78.1 254.16,96.41 v2(253.75,95.99) U12.16
  BOTTOM w0.127: R78.1 254.16,96.41 v2(253.75,95.99)
CPLD_RDN: length 36.9
  TOP w0.127: U12.12 v2(253.75,92.79)
  BOTTOM w0.127: R615.1 R616.1 245.97,67.88 247.42,69.33 250.04,69.33 256.41,75.71 256.41,90.12 v2(253.75,92.79)
CPLD_RESETN: length 59.1
  TOP w0.127: R79.1 254.66,93.27 254.06,93.27 v2(253.75,93.59) U12.13 ; U17.B10 v1(241.42,58.05)
  L08_SIG2 w0.102: 250.98,56.66 250.91,56.59 250.46,56.59 250.45,56.58 250.13,56.58 250.06,56.66 247.4,56.66 245.84,55.1 245.84,54.64 245.85,54.63 245.67,54.45 242.77,54.45 242.62,54.6 242.62,56.85 v1(241.42,58.05)
  L08_SIG2 w0.127: v2(253.75,93.59) 255.85,91.48 255.85,59.02 253.49,56.66 250.98,56.66
CPLD_RXD1: length 62.9
  TOP w0.127: R148.2 234.31,94.63 v2(234.06,94.38) ; U17.E18 247.8,55.63 v1(249.02,55.63)
  L03_SIG1 w0.102: 250.98,58.51 249.02,56.56 v1(249.02,55.63)
  L03_SIG1 w0.127: 250.98,58.51 251.59,59.12 251.59,59.96 254.76,63.13 254.76,73.47 250.04,78.2 244.42,78.2 240.64,81.98 240.64,95.93 239.29,97.27 236.96,97.27 v2(234.06,94.38)
CPLD_TCK: length 83.1
  TOP w0.127: U12.11 249.62,89.42 251.31,87.73 251.31,85.98 251.18,85.85 R45.1 250.44,84.14 J4.2 ; R189.1 v2(234.54,38.2)
  L08_SIG2 w0.102: 232.92,42.28 232.92,44.46 232.21,45.18
  L08_SIG2 w0.127: 232.21,45.18 231.97,45.42 231.84,45.42 230.25,47 230.25,53.23 227.91,55.56 227.91,61.31 228.73,62.12 228.73,67.07 229.34,67.68 229.34,69.79 228.46,70.67 228.46,70.67 226.87,72.26 226.87,75.81 231.11,80.05 237.57,80.05 241.4,83.89 250.7,83.89 J4.2 ; v2(234.54,38.2) 234.95,38.61 234.95,39.99 232.92,42.03 232.92,42.28
CPLD_TDI: length 72.3
  TOP w0.127: U17.U1 233.4,45.23 v2(233.4,42.43) ; U12.9 248.02,88.69 247.47,88.14 247.47,84.22 246.91,83.66 J4.4
  L08_SIG2 w0.127: v2(233.4,42.43) 235.18,42.43 235.51,42.76 235.51,43.5 231.24,47.77 231.24,55.08 229.9,56.43 229.9,63.67 229.35,64.21 229.35,66.7 229.9,67.25 229.9,67.36 229.96,67.42 229.96,70.05 229.9,70.11 229.9,70.71 229.9,70.94 228.8,72.04 228.8,73.7 229.36,74.25 229.36,77.2 231.11,78.96 243.28,78.96 J4.4
CPLD_TDO: length 84.9
  TOP w0.127: v2(248.82,104.92) U12.24 ; U17.U2 235.05,45.22 v2(235.05,42.99)
  L03_SIG1 w0.127: v2(248.82,104.92) 248.82,91.91 246.56,89.65 246.56,86.3 244.37,84.11 J4.5
  L08_SIG2 w0.127: v2(235.05,42.99) 230.84,47.21 230.84,55.09 228.93,57 228.93,61.78 229.11,61.96 229.11,66.89 229.62,67.4 229.62,67.42 229.72,67.52 229.72,69.95 229.62,70.05 229.62,70.83 228.87,71.58 228.47,71.97 228.47,73.78 229.08,74.38 229.08,77.32 231,79.24 231.09,79.24 231.47,79.62 241.4,79.62 J4.5
CPLD_TMS: length 73.9
  TOP w0.127: U12.10 248.82,89.04 248.06,88.28 248.06,86.04 248.28,85.82 248.7,85.82 R46.1 248.72,84.52 248.41,84.22 248.41,83.63 J4.3 ; U17.V3 235.81,44.45 v2(235.81,41.85)
  L08_SIG2 w0.127: v2(235.81,41.85) 235.81,43.63 231.6,47.84 231.6,55.12 230.17,56.54 230.17,64 229.59,64.58 229.59,66.39 230.23,67.02 230.23,71.01 229.13,72.1 229.13,73.62 229.64,74.13 229.64,77.07 230.42,77.85 244.72,77.85 J4.3
